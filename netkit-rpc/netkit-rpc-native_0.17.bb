include netkit-rpc_${PV}.bb
inherit native

FILESPATH = "${FILE_DIRNAME}/netkit-rpc-${PV}:${FILE_DIRNAME}/netkit-rpc:${FILE_DIRNAME}/files:${FILE_DIRNAME}"
