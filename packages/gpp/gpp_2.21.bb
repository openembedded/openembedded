SECTION = "devel"
LICENSE = "GPL"
DESCRIPTION = "GPP is a general-purpose preprocessor with \
customizable syntax, suitable for a wide range of \
preprocessing tasks."

SRC_URI = "http://www.nothingisreal.com/gpp/gpp-${PV}.tar.bz2"

inherit autotools
