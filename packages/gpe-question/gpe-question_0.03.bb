LICENSE = "GPL"
inherit gpe

DEPENDS = "libgpewidget"
RDEPENDS = "gpe-icons"
SECTION = "gpe"
DESCRIPTION = "GPE interface for asking questions from shell scripts"
