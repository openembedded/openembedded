inherit gpe

DEPENDS = "libxsettings glib-2.0"
SECTION = "gpe"
DESCRIPTION = "GPE configuration daemon"
LICENSE = "GPL"
PR = "r1"

