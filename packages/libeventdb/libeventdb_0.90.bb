require libeventdb.inc

FILE_PR = "r2"
SRC_URI += "file://libeventdb-unbreak-LIVE-macro.patch;patch=1"
