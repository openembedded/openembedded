require libeventdb.inc

FILE_PR = "r1"
DEFAULT_PREFERENCE = "-1"
