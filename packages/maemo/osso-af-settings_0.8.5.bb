LICENSE    =	"LGPL"
MAINTAINER =	"Florian Boor <florian@kernelconcepts.de"

DEPENDS =	""
SRC_URI =	"http://stage.maemo.org:80/pool/maemo/ossw/source/o/${PN}/${PN}_${PV}-1.tar.gz"

inherit autotools pkgconfig
