require exmap-console.inc

