require exmap-console.inc

FILE_PR = "r5"
