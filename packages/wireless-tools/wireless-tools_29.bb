require wireless-tools.inc

FILE_PR = "r0"
