PR = "r0"

require dropbear.inc

# testing
DEFAULT_PREFERENCE = "-1"
