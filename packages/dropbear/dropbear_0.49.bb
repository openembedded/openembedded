require dropbear.inc

FILE_PR = "r2"

SRC_URI += "file://scp-argument-fix.patch;patch=1"
