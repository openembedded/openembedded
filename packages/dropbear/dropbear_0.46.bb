require dropbear.inc

PR = "r5"

SRC_URI += "file://chansession-security-fix.patch;patch=1 "
