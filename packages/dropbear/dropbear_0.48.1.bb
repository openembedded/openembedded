require dropbear.inc

EXTRA_OECONF_append = "--disable-wtmp --disable-wtmpx"

PR = "r1"
