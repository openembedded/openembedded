require dropbear.inc
FILE_PR = "r1"

SRC_URI += "file://no-host-lookup.patch;patch=1"