require dropbear.inc

PR = "r3"

SRC_URI += "file://chansession-security-fix.patch;patch=1 "
