DESCRIPTION = "ddccontrol - softwarewise change monitor settings"
LICENSE = "GPLv2"
HOMEPAGE = "http://sourceforge.net/projects/ddccontrol/"

PR = "r0"

inherit autotools

SRC_URI = "${SOURCEFORGE_MIRROR}/ddccontrol/ddccontrol-db-${PV}.tar.bz2"

