require avahi.inc

PR = "r1"

do_stage() {
	autotools_stage_all
}
