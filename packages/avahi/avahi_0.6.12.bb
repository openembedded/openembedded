require avahi.inc

PR = "r2"

do_stage() {
	autotools_stage_all
}
