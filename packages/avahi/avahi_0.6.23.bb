require avahi.inc

DEPENDS += "intltool-native"

PACKAGES =+ "libavahi-gobject"
