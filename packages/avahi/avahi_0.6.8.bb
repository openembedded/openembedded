require avahi.inc
