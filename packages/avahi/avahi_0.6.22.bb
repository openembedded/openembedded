require avahi.inc

DEPENDS += "intltool-native"
FILE_PR = "r8"

PACKAGES =+ "libavahi-gobject"
