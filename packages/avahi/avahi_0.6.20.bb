require avahi.inc

FILE_PR = "r9"
