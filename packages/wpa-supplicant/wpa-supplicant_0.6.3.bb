require wpa-supplicant-0.6.inc

FILE_PR = "r1"
