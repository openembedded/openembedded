SECTION = "gpe"
DESCRIPTION = "Editor for the GPE Palmtop Environment"
LICENSE = "GPL"
FILE_PR = "r1"

DEPENDS = "gtk+ libgpewidget"

inherit gpe
