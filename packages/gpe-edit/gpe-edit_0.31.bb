LICENSE = "GPL"
inherit gpe

DEPENDS = "gtk+ libgpewidget"
MAINTAINER = "Phil Blundell <pb@handhelds.org>"
SECTION = "gpe"
DESCRIPTION = "Editor for the GPE Palmtop Environment"

