LICENSE = "GPL"
inherit gpe

DEPENDS = "gtk+ libdisplaymigration libgpewidget"
SECTION = "gpe"
DESCRIPTION = "Editor for the GPE Palmtop Environment"

