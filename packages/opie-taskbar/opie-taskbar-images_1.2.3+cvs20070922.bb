require ${PN}.inc

FILE_PR = "r1"
SRCDATE = "20070922"
SRC_URI = "${HANDHELDS_CVS};module=opie/pics"
