require ${PN}.inc

PV = "${OPIE_CVS_PV}"
FILE_PR = "r7"
SRC_URI = "${HANDHELDS_CVS};module=opie/pics"
