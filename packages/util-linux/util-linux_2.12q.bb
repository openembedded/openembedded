# fdisk gets a #error unknown architecture when compiling for ARM thumb
#FIXME: remove this
ARM_INSTRUCTION_SET = "arm"

require util-linux.inc

PR = "r5"
