require ${PN}.inc
# This has not been released yet!
DEFAULT_PREFERENCE = "-1"
FILE_PR = "r0"
