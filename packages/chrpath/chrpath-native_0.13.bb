require chrpath.inc

inherit native
