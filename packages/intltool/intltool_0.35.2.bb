require intltool.inc

DEPENDS = "libxml-parser-perl-native"
RDEPENDS = "perl-module-text-wrap perl-module-re"

FILE_PR = "r1"

RRECOMMENDS = "perl-modules"
