require intltool.inc
