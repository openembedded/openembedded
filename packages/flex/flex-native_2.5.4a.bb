include flex.inc
inherit native

S = "${WORKDIR}/flex-2.5.4"
PR = "r1"
