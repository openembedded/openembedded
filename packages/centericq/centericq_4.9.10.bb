require centericq.inc

acpaths = "-I ${S}/m4"
