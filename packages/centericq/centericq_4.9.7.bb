require centericq.inc
