MAINTAINER = "Greg Gilbert <greg@treke.net>"
DESCRIPTION = "various extension headers."

SRC_URI = "${XLIBS_CVS};module=XExtensions;date=20050418"
S = "${WORKDIR}/XExtensions"

inherit xlibs
