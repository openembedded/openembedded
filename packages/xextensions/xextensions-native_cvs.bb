SECTION = "unknown"
require xextensions_cvs.bb
inherit native
PROVIDES = ""
