CMAKE_MAJOR_VERSION="2.4"
require cmake.inc
inherit native
