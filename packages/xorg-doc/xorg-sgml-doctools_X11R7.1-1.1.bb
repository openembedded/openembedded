include xorg-doc-common.inc

#DESCRIPTION = ""

#DEPENDS += " "

FILES_${PN} += " /usr/share/X11/sgml"
