require xorg-doc-common.inc
PE = "1"

FILES_${PN} += " /usr/share/X11/sgml"
