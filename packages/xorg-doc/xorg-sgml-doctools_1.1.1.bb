require xorg-doc-common.inc
PE = "1"

#DESCRIPTION = ""

#DEPENDS += " "

FILES_${PN} += " /usr/share/X11/sgml"
