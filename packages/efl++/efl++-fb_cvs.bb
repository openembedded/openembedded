include efl++.inc

PV = "0.1.0+cvs${SRCDATE}"

SRC_URI = "cvs://anonymous@projects.linuxtogo.org/cvsroot/eflpp;module=efl++"
S = "${WORKDIR}/efl++"



