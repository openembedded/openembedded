# xfce-calendar OE build file
# Copyright (C) 2004, Advanced Micro Devices, Inc.  All Rights Reserved
# Released under the MIT license (see packages/COPYING)

DESCRIPTION="XFCE Calendar"
SECTION = "x11"
DEPENDS="x11 libxfcegui4 libxfce4mcs"
inherit xfce
