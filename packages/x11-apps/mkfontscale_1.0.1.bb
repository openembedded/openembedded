include app-common.inc
DEPENDS = "libfontenc freetype"
