include app-common.inc
DEPENDS = "libxfont"
