include app-common.inc
DEPENDS = "mkfontscale"
