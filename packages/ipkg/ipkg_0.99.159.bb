include ipkg.inc

PR = "r1"

#SRC_URI += "file://interceptor.patch;patch=1;pnum=1"
