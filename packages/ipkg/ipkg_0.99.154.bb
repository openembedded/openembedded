include ipkg.inc

SRC_URI += "file://libbb_tar_gnu_extensions.patch;patch=1"
