PR = "r0"

inherit gpe

DESCRIPTION = "GPE vtype file tools"
DEPENDS = "libmimedir libgpevtype"
SECTION = "gpe"
PRIORITY = "optional"
LICENSE = "GPL"

