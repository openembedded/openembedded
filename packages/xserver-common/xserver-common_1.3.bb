require xserver-common.inc

PR = "r1"
