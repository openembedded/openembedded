include proto-common.inc

SRC_URI = "http://xcb.freedesktop.org/dist/${P}.tar.bz2"



