DESCRIPTION =	"NX is an exciting new technology for remote display. It provides near local speed application responsiveness over high latency, low bandwidth links."
LICENSE =	"GPL"
HOMEPAGE =	"http://freenx.berlios.de/"

DEPENDS = 	""

SRC_URI =	"http://download.berlios.de/freenx/freenx-${PV}.tar.gz"
inherit autotools
