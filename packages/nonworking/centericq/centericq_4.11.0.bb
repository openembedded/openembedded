require centericq.inc

acpaths = "-I ${S}/m4"

# FIXME: ugly compile failures
BROKEN = "1"
