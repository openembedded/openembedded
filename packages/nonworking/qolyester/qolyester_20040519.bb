DESCRIPTION = "A routing Daemon for the OLSR protocol prepared for QoS enhancements."
SECTION = "net"
PRIORITY = "optional"
MAINTAINER = "Michael Lauer <mickey@Vanille.de>"

SRC_URI = "http://qolsr.lri.fr/code/qolyester-${PV}.tar.bz2"

inherit autotools

