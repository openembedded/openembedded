require glibc_${PV}.bb
require glibc-intermediate.inc
