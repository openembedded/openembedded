TOOLCHAIN_TARGET_TASK = "\
    task-sdk-base \
    task-sdk-sbox \
    task-sdk-sbox-gpe \
    task-sdk-x11 \
    task-sdk-x11-ext \
    task-sdk-gpe \
    task-sdk-gpephone"

require meta-toolchain.bb

