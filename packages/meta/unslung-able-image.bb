IMAGE_VARIANT = "able"

include unslung-standard-image.bb
LICENSE = MIT
