TOOLCHAIN_TARGET_TASK = "\
    task-sdk-base \
    task-sdk-opie"

require meta-toolchain.bb

SDK_SUFFIX = "toolchain-opie"
