DESCRIPTION = "Meta-package for a network attached storage server"
LICENSE = "MIT"
FILE_PR = "r0"

RDEPENDS = "\
	task-nas-server-everything \
	"

inherit meta

