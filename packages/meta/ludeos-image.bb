DEPENDS = openslug-image