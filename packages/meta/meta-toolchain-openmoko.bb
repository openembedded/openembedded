TOOLCHAIN_TARGET_TASK = "task-toolchain-openmoko-sdk"
RDEPENDS = "${TOOLCHAIN_TARGET_TASK}"

require meta-toolchain.bb

