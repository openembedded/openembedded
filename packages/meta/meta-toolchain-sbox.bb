TOOLCHAIN_TARGET_TASK = "\
    task-sdk-bare \
    task-sdk-sbox"

require meta-toolchain.bb

