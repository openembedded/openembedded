DEPENDS = openslug-packages
