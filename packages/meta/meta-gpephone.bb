DESCRIPTION = "Meta-package for GPE Palmtop Environment Phone packages"
LICENSE = "MIT"
PR = "r0"

RDEPENDS = "\
    gpe-base-depends \
    gpephone-task-base \
    gpephone-task-settings \
    gpephone-task-pim \
    gpeph-task-connectivity"

inherit meta