require lasertraq.inc


FILES_${PN} += "${datadir}/gnome ${datadir}/traqConfig"
FILES_${PN}-doc += "/usr/doc/"

