include mathomatic.inc

SRC_URI = "http://www.panix.com/~gesslein/mathomatic-${PV}.tgz"
