LICENSE = "GPL"
DESCRIPTION = "GPE modal help"
DEPENDS = "virtual/x11 gtk+"


GPE_TARBALL_SUFFIX= "bz2"
inherit autotools gpe

