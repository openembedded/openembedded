require embryo_${PV}.bb
inherit native

