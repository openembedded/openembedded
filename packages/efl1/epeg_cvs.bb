DESCRIPTION = "Epeg is a small library for handling thumbnails."
LICENSE = "MIT"
DEPENDS = "jpeg"
PV = "0.9.0+cvs${SRCDATE}"
PR = "r0"

inherit efl_library
