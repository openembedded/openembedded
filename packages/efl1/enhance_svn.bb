DESCRIPTION = "Enhance translates between glade .xml files and ETK"
LICENSE = "MIT"
DEPENDS = "exml"
PV = "0.0.0+svnr${SRCREV}"
FILE_PR = "r1"

inherit efl
