DESCRIPTION = "Evolve allows you to write ETK designs using a C-like language"
LICENSE = "MIT"
DEPENDS = "etk evolve-native"
PV = "0.0.0+svnr${SRCREV}"
PR = "r2"

inherit efl
