DESCRIPTION = "Exml is a generic XML parser wrapper."
LICENSE = "MIT"
DEPENDS = "libxml2 libxslt ecore"
PV = "0.1.1+svnr${SRCREV}"
FILE_PR = "r2"

inherit efl

