require wview-common.inc
require wview.inc
EXTRA_OECONF += " --enable-station-sim"
FILE_PR = "r1"
