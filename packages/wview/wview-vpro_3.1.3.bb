require wview-common.inc
require wview.inc
EXTRA_OECONF += " --enable-station-vpro"
FILE_PR = "r1"
