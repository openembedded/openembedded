require wview-common.inc
require wview.inc
EXTRA_OECONF += " --enable-station-wxt510"
FILE_PR = "r1"
