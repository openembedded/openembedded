DESCRIPTION = "Sync daemon for GPE and OpenSync"
LICENSE = "GPL"
DEPENDS = "gtk+ glib-2.0 libgpewidget"

GPE_TARBALL_SUFFIX = "bz2"

inherit gpe autotools

