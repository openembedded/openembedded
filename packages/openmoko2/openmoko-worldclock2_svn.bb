DESCRIPTION = "A World-Clock for OpenMoko"
SECTION = "openmoko/tools"
DEPENDS = "libmokoui2 openmoko-dates2"
PV = "0.1.0+svn${SVNREV}"

inherit openmoko2
