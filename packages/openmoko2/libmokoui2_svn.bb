SECTION = "openmoko/libs"
DEPENDS = "gtk+"
PV = "0.1.0+svn${SRCDATE}"

inherit openmoko2

