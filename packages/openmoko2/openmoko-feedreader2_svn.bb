DESCRIPTION = "The OpenMoko Feed Reader"
SECTION = "openmoko/apps"
DEPENDS += "libmokoui2 libmrss check webkit-gtk"
PV = "0.0.1+svn${SVNREV}"
PR = "r0"

inherit openmoko2
