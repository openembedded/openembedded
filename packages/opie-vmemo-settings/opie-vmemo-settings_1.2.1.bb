include ${PN}.inc
    
 

SRC_URI = "${HANDHELDS_CVS};tag=${TAG};module=opie/noncore/settings/sound \
           ${HANDHELDS_CVS};tag=${TAG};module=opie/apps"
