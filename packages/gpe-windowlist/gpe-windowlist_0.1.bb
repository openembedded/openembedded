DEPENDS = "libgpewidget libgpelaunch gtk+"
SECTION = "gpe"
DESCRIPTION = "GPE windowlist applet"
LICENSE = "GPL"

FILE_PR = "r0"

GPE_TARBALL_SUFFIX = "bz2"

inherit autotools gpe




