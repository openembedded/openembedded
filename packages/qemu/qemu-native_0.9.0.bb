require qemu_0.9.0.bb
inherit native
require qemu-native.inc
