require qemu_0.9.0+cvs.bb
inherit native
require qemu-native.inc
