require qemu_svn.bb
require qemu-native.inc

DEFAULT_PREFERENCE = "-99"
