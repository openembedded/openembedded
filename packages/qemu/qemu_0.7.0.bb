LICENSE = "GPL"

SRC_URI = "http://fabrice.bellard.free.fr/qemu/qemu-${PV}.tar.gz"

inherit autotools

