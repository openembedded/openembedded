require qemu_${PV}.bb
inherit native
require qemu-native.inc
S = "${WORKDIR}/qemu-${PV}"

