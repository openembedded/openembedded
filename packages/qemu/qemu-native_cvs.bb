require qemu_cvs.bb
inherit native
# prefix = "${STAGING_DIR}/${BUILD_SYS}"
inherit qemu-native.inc
