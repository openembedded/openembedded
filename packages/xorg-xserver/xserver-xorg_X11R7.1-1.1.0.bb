include xorg-xserver-common.inc

SRC_URI += "file://drmfix.patch;patch=1"

#DESCRIPTION = ""

#DEPENDS += " "
