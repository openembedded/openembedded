include ${PN}.inc
    
 

SRC_URI = "${HANDHELDS_CVS};tag=${TAG};module=opie/noncore/settings/language \
           ${HANDHELDS_CVS};tag=${TAG};module=opie/apps"
