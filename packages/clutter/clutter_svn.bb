require clutter.inc

PV = "0.2.0+svn${SRCDATE}"

SRC_URI = "svn://svn.o-hand.com/repos/clutter/trunk;module=clutter;proto=http"

S = "${WORKDIR}/clutter"


