require sylpheed-claws-extra-plugins.inc

SRC_URI = "http://www.sylpheed-claws.net/downloads/plugins/mailmbox-1.12.1.tar.gz"
S = "${WORKDIR}/mailmbox-1.12.1" 

