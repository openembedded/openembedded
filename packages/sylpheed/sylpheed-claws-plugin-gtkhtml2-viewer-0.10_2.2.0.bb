include sylpheed-claws-extra-plugins.inc

DEPENDS_append = " gtkhtml2"

S = ${WORKDIR}/sylpheed-claws-extra-plugins-${PV}/gtkhtml2_viewer-0.10

