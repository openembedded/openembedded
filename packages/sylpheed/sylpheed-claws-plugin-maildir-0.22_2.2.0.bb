include sylpheed-claws-extra-plugins.inc

DEPENDS_append = " db"

S = ${WORKDIR}/sylpheed-claws-extra-plugins-${PV}/maildir-0.22

