require libftdi_${PV}.bb

inherit native

DEPENDS = "libusb-native"
