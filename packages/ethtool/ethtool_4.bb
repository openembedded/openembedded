require ethtool.inc
FILE_PR ="r0"
