require ethtool.inc
FILE_PR ="r1"
