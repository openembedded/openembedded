require xserver-kdrive-splash_${PV}.bb
