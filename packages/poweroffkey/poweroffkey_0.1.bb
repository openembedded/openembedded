LICENSE = "PD"
inherit gpe

DESCRIPTION = "power off key hack"

SECTION = "base"
PRIORITY = "optional"

SRC_URI="file:///home/ph5/src/hx4700/${PN}-${PV}.tar.gz"
