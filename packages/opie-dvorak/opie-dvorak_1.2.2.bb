include ${PN}.inc
    
 

SRC_URI = "${HANDHELDS_CVS};tag=${TAG};module=opie/inputmethods/dvorak \
           ${HANDHELDS_CVS};tag=${TAG};module=opie/inputmethods/pickboard"
