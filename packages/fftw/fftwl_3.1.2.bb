require fftw.inc

EXTRA_OECONF = "--disable-fortran --enable-long-double --enable-shared"


