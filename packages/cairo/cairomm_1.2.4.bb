require cairo.inc

DEPENDS = "cairo"
DESCRIPTION = "C++ bindings for Cairo graphics library"
FILE_PR = "r0"

SRC_URI = "http://cairographics.org/releases/cairomm-${PV}.tar.gz"

#EXTRA_OECONF = "--disable-docs"
