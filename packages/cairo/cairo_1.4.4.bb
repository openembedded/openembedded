require cairo.inc

SRC_URI = "http://cairographics.org/releases/cairo-${PV}.tar.gz \
           file://cairo-workqueue.patch;patch=1"

PR = "r0"

