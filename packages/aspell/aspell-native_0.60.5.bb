require aspell_${PV}.bb

inherit native

S = "${WORKDIR}/aspell-${PV}"

