SRC_URI = "ftp://ftp.gnu.org/gnu/aspell/dict/en/aspell5-en-${PV}.tar.bz2"

require aspell-lang.inc

