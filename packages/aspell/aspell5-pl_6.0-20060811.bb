# The dictionary is licensed under GPL, LGPL, MPL and Creative Commons ShareAlike licenses.
LICENSE = "GPL"
HOMEPAGE = "http://www.kurnik.pl/dictionary/ http://www.kurnik.pl/slownik/os.phtml"

SRC_URI = "http://www.kurnik.pl/slownik/ort/alt-aspell5-pl-${PV}.tar.bz2"

require aspell-lang.inc
