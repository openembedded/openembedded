require gpe-bluetooth.inc

FILE_PR = "r0"

