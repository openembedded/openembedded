require gdb.inc

RDEPENDS_openmn = "libthread-db1"
