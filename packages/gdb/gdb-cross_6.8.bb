require gdb-cross.inc
inherit cross

FILE_PR = "r2"
