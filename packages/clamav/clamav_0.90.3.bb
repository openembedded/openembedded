require clamav.inc

FILE_PR = "r1"
