require clamav.inc

PR = "r1"

SRC_URI_append += " file://libtool-fix.patch;patch=1"
