require clamav.inc

PR = "r6"
