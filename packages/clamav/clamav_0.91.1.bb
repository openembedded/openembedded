DEFAULT_PREFERENCE = "-1"

require clamav.inc

PR = "r0"
