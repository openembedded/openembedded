require efreet_${PV}.bb
inherit native
DEPENDS = "ecore-native"
