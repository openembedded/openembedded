require imlib2.inc
PR = "r1"

EXTRA_OECONF = "--without-x \
		--disable-mmx"

