include eet_${PV}.bb
inherit native
DEPENDS = "zlib-native jpeg-native"

