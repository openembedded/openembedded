include imlib2.inc
PROVIDES += "virtual/imlib2"

EXTRA_OECONF = "--without-x \
		--disable-mmx"

