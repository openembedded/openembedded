DESCRIPTION = "Etox is a type setting and text layout library based on Evas. \
Etox helps you when it comes to displaying, moving, resizing, layering, \
clipping, aligning and coloring fonts in different styles, and more."
DEPENDS = "edb virtual/evas virtual/ecore"
LICENSE = "MIT"
PR = "r1"

inherit efl

libdirectory = "src"
