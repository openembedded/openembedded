require abiword.inc

RCONFLICTS = "abiword-embedded"

