require abiword-2.5.inc

DEFAULT_PREFERENCE = "-1"

FILE_PR = "r2"

RCONFLICTS = "abiword-embedded"
