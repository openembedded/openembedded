require abiword-2.5.inc

DEFAULT_PREFERENCE = "-1"

FILE_PR = "r1"

RCONFLICTS = "abiword-embedded"
