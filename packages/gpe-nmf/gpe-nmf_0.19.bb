LICENSE = "GPL"
inherit gpe pkgconfig

DESCRIPTION = "GPE audio player"
DEPENDS = "gtk+ libgpewidget gstreamer"
RDEPENDS = "gst-plugins"
SECTION = "gpe"
PRIORITY = "optional"
PR = "r1"

