require gpe-nmf.inc

RRECOMMENDS += "gst-plugin-tcp"
