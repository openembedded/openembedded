DESCRIPTION = "DejaVu Sans Mono font - QPF Edition"

require qpf-dejavu.inc
