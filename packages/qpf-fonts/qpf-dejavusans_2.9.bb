DESCRIPTION = "DejaVu Sans font - QPF Edition"

require qpf-dejavu.inc
