DESCRIPTION = "DejaVu Serif font - QPF Edition"

require qpf-dejavu.inc
