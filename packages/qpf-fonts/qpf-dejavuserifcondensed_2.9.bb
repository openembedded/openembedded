DESCRIPTION = "DejaVu Serif Condensed font - QPF Edition"

require qpf-dejavu.inc
