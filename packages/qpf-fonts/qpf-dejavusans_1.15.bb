DESCRIPTION = "DejaVu Sans font - QPF Edition"

include qpf-dejavu.inc
