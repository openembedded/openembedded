DESCRIPTION = "DejaVu Serif font - QPF Edition"

include qpf-dejavu.inc
