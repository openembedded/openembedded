DESCRIPTION = "DejaVu Sans Mono font - QPF Edition"

include qpf-dejavu.inc
