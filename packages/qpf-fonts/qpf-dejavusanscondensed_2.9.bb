DESCRIPTION = "DejaVu Sans Condensed font - QPF Edition"

require qpf-dejavu.inc
