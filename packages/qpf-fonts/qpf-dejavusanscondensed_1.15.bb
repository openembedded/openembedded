DESCRIPTION = "DejaVu Sans Condensed font - QPF Edition"

include qpf-dejavu.inc
