DESCRIPTION = "DejaVu Serif Condensed font - QPF Edition"

include qpf-dejavu.inc
