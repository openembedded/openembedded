include giblib.inc

PR = "r3"

SRC_URI += "file://pkgconfig.patch;patch=1"
