SRC_URI = "http://gnokii.org/download/gnocky/gnocky-${PV}.tar.bz2"
LICENSE = "GPL"
DEPENDS = "gtk+ gnokii"
DESCRIPTION = "GTK+ frontend for Gnokii"

inherit autotools

