require mono.inc

DEPENDS = "glib-2.0-native"

inherit native
