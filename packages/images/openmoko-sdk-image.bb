require openmoko-devel-image.bb

export PACKAGE_INSTALL += "\
  task-openmoko-native-sdk \
"
