#------------------------------------------------------
# Openmoko Bare Image Recipe
#------------------------------------------------------

require openmoko-minimal-image.bb

IMAGE_INSTALL += "task-openmoko-bare"
