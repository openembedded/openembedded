DEPENDS = "slugos-image"
COMPATIBLE_MACHINE = "nslu2"
