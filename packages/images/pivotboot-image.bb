export IMAGE_BASENAME = "pivotboot-image"
export IMAGE_LINGUAS = ""
export PACKAGE_INSTALL = "task-pivotboot"

DEPENDS = "task-pivotboot"
PR = "r1"

inherit image

LICENSE = "MIT"
