#------------------------------------------------------
# Openmoko Base Image Recipe
#------------------------------------------------------

require openmoko-minimal-image.bb

IMAGE_INSTALL += "task-openmoko-basic"
