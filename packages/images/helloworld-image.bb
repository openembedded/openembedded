# Hello world image
# Contains *only* a statically linked hello world init program
LICENSE = "MIT"
PR = "r0"

RDEPENDS = "helloworld"

export IMAGE_BASENAME = "helloworld-image"
export IMAGE_LINGUAS = ""

PACKAGE_INSTALL = ${RDEPENDS}

inherit image

# Hello world image
# Contains *only* a statically linked hello world init program
LICENSE = "MIT"
PR = "r0"

RDEPENDS = "helloworld"

export IMAGE_BASENAME = "helloworld-image"
export IMAGE_LINGUAS = ""

PACKAGE_INSTALL = ${RDEPENDS}

inherit image

