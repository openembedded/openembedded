include mpfr_${PV}.bb
DEPENDS = "gmp-native"
S = "${WORKDIR}/mpfr-${PV}"
inherit native

