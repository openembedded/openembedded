inherit gpe autotools

PR = "r0"
DESCRIPTION = "GPE wireless LAN communication applet"
DEPENDS  = "gtk+ libgpewidget prismstumbler"
RDEPENDS = "prismstumbler"
SECTION  = "gpe"
PRIORITY = "optional"
LICENSE  = "GPL"

GPE_TARBALL_SUFFIX = "bz2"
