include ${PN}.inc
    
PV = "1.2.1+cvs-${CVSDATE}"

