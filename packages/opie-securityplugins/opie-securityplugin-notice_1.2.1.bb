include opie-securityplugin-notice.inc

SRC_URI = "${HANDHELDS_CVS};tag=${TAG};module=opie/noncore/securityplugins/notice \
           ${HANDHELDS_CVS};tag=${TAG};module=opie/pics "

