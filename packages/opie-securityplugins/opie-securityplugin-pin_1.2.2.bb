include opie-securityplugin-pin.inc

SRC_URI = "${HANDHELDS_CVS};tag=${TAG};module=opie/noncore/securityplugins/pin \
           ${HANDHELDS_CVS};tag=${TAG};module=opie/pics"

