include opie-securityplugin-dummy.inc

SRC_URI = "${HANDHELDS_CVS};tag=${TAG};module=opie/noncore/securityplugins/dummy \
           ${HANDHELDS_CVS};tag=${TAG};module=opie/pics "

