include opie-securityplugin-blueping.inc

PV = "${OPIE_CVS_PV}"

SRC_URI = "${HANDHELDS_CVS};module=opie/noncore/securityplugins/blueping \
           ${HANDHELDS_CVS};module=opie/pics "

