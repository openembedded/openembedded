SRC_URI = "http://ewi546.ewi.utwente.nl/OE/source/${P}.tar.gz"


LICENSE = "GPL"
DEPENDS = "libopensync"
HOMEPAGE = "http://www.opensync.org/"
MAINTAINER = "Koen Kooi <koen@handhelds.org>"

inherit autotools pkgconfig


