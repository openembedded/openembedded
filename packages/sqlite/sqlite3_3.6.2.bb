require sqlite3.inc

FILE_PR = "r0"
