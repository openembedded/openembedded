require sqlite3.inc
PR = "r1"
SRC_URI += "file://cross-compile.patch;patch=1 file://ldflags.patch;patch=1"
