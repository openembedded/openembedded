require gtkmm.inc

PR = "r0"

SRC_URI = "${GNOME_MIRROR}/gtkmm/2.8/gtkmm-${PV}.tar.bz2"
