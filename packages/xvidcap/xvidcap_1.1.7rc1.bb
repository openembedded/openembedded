require xvidcap.inc

PR = "r0"

# 1.1.7rc1 still uses this directory name
S = "${WORKDIR}/${PN}-1.1.6"
