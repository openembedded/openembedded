require xvidcap.inc

FILE_PR = "r0"

