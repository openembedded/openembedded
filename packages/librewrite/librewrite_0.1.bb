LICENSE = "LGPL"
DESCRIPTION = "Application relocator library"
SECTION = "libs"
MAINTAINER = "Philip Blundell <pb@handhelds.org>"

inherit autotools

SRC_URI = "${GPE_MIRROR}/${PN}-${PV}.tar.bz2"

