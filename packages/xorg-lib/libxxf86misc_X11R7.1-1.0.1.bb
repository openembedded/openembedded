include xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " xproto libx11 xextproto libxext xf86miscproto"
PROVIDES = "xxf86misc"

XORG_PN = "libXxf86misc"

