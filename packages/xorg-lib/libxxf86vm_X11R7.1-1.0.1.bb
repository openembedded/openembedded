include xorg-lib-common.inc

DESCRIPTION = "Xxf86vm extension library."

DEPENDS += " xproto libx11 xextproto libxext xf86vidmodeproto"

XORG_PN = "libXxf86vm"

