include xorg-lib-common.inc

DESCRIPTION = "Xxf86dga extension library."

DEPENDS += " xproto virtual/x11 xextproto libxext xf86dgaproto"

XORG_PN = "libXxf86dga"

