require xorg-lib-common.inc

DESCRIPTION = "X11 Distributed Multihead extension library"
DEPENDS += "libxext dmxproto"
FILE_PR = "r1"
PE = "1"
