include xorg-lib-common.inc

DESCRIPTION = "X Fixes extension library."
LICENSE= "BSD-X"

DEPENDS += " virtual/x11 xproto fixesproto xextproto"

XORG_PN = "libXfixes"

