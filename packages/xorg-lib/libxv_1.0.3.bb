require xorg-lib-common.inc

DESCRIPTION = "X11 Video extension library"
LICENSE = "GPL"
DEPENDS += "libxext videoproto"
FILE_PR = "r1"

XORG_PN = "libXv"
