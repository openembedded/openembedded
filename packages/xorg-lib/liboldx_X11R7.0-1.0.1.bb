include xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " libx11"

XORG_PN = "liboldX"

