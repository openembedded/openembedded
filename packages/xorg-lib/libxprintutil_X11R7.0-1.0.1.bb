include xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " libx11 libxp libxt printproto libxau"

XORG_PN = "libXprintUtil"

