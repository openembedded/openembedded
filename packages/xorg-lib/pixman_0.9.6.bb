DESCRIPTION = "Library for lowlevel pixel operations"

SRC_URI = "http://cairographics.org/releases/pixman-${PV}.tar.gz"
