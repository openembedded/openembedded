include xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " xproto libx11 xextproto libxext evieext"

XORG_PN = "libXevie"

