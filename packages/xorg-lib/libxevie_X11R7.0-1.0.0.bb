include xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " xproto virtual/x11 xextproto libxext evieext"

XORG_PN = "libXevie"

