include xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " libx11 libxext xextproto fontcacheproto"

XORG_PN = "libXfontcache"

