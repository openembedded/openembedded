include xorg-lib-common.inc

DESCRIPTION = "X Input extension library."

DEPENDS += " xproto virtual/x11 xextproto libxext inputproto"

XORG_PN = "libXi"

