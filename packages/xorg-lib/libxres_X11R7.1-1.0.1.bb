include xorg-lib-common.inc

DESCRIPTION = "X Resource usage library."

DEPENDS += " libx11 libxext xextproto resourceproto"

XORG_PN = "libXres"

