include xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " libx11 libxext xextproto windowswmproto"

XORG_PN = "libWindowsWM"

