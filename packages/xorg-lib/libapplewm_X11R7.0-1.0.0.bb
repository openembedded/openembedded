include xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " libx11 libxext xextproto applewmproto"

XORG_PN = "libAppleWM"

