require xorg-lib-common.inc

DESCRIPTION = "X Video Motion Compensation extension library"
DEPENDS += "libxext libxv videoproto"
FILE_PR = "r1"
PE = "1"

XORG_PN = "libXvMC"
