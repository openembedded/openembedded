require xorg-lib-common.inc

DESCRIPTION = "X cursor management library"
LICENSE= "BSD-X"
DEPENDS += "libxrender libxfixes"
PE = "1"

XORG_PN = "libXcursor"
