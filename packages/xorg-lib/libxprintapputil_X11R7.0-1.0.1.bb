include xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " virtual/x11 libxp libxprintutil printproto libxau"

XORG_PN = "libXprintAppUtil"

