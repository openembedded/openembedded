require xorg-lib-common.inc

DESCRIPTION = "X11 keyboard file manipulation library"
LICENSE= "GPL"
DEPENDS += "virtual/libx11 kbproto"
FILE_PR = "r1"
PE = "1"
