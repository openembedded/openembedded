require libxfixes_${PV}.bb

DEPENDS = "libx11-native"
PE = "1"

inherit native
