include xorg-lib-common.inc

DESCRIPTION = "X Video Motion Compensation extension library."

DEPENDS += " virtual/x11 libxext libxv xextproto videoproto"

XORG_PN = "libXvMC"

