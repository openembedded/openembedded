require xorg-lib-common.inc

DEPENDS += "libxext applewmproto"
FILE_PR = "r1"
PE = "1"

XORG_PN = "libAppleWM"
