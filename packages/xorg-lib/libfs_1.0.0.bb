require xorg-lib-common.inc

DESCRIPTION = "X11 Font Services library"
DEPENDS += "xproto fontsproto xtrans"
FILE_PR = "r1"
PE = "1"

XORG_PN = "libFS"
