include xorg-lib-common.inc

#DESCRIPTION = ""

DEPENDS += " libx11 libxt trapproto libxext xextproto"

XORG_PN = "libXTrap"

