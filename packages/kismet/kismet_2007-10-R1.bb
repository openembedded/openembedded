require kismet.inc

SRC_URI += "file://fix_strip.patch;patch=1"

FILE_PR = "r5"
