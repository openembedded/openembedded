require libxsettings-client.inc

FILE_PR = "r1"

SRC_URI = "${GPE_MIRROR}/xsettings-client-${PV}.tar.bz2"
