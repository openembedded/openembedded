require libxsettings-client.inc

SRC_URI += "        file://Makefile-am.patch;patch=1"


FILE_PR ="r2"
