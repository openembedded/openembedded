DESCRIPTION = "Password generator which creates passwords which can be easily memorized by a human"
HOMEPAGE = "http://sf.net/projects/pwgen/"
LICENSE = "GPL"

SRC_URI = "${SOURCEFORGE_MIRROR}/pwgen/pwgen-${PV}.tar.gz"

inherit autotools
