include ${PN}.inc

SRCDATE = 20051027

SRC_URI = "${HANDHELDS_CVS};module=opie/core/pim/notes \
           ${HANDHELDS_CVS};module=opie/pics \
           ${HANDHELDS_CVS};module=opie/apps"
