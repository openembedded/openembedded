include ${PN}.inc

CVSDATE = 20051021

SRC_URI = "${HANDHELDS_CVS};module=opie/core/pim/notes \
           ${HANDHELDS_CVS};module=opie/pics;date=20051026 \
           ${HANDHELDS_CVS};module=opie/apps;date=20051026"

# code was commited in 20051020
# icon and .desktop file added 20051025
