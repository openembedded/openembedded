include ${PN}.inc

PV = "0.3+cvs${SRCDATE}"
