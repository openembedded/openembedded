require binutils_${PV}.bb
require binutils-cross-sdk.inc
FILE_PR = "r4"
