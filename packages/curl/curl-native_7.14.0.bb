include curl_${PV}.bb
inherit native

