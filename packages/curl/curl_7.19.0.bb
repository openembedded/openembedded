require curl.inc

SRC_URI += "file://off_t_abi_fix.patch;patch=1;pnum=0"
FILE_PR = "r1"

