require libgpepimc.inc
FILE_PR = "r1"

SRC_URI += " file://get-category-by-name.patch;patch=1"
