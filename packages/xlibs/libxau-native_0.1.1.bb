SECTION = "x11/base"
include libxau_${PV}.bb
inherit native
DEPENDS = "xproto-native"
PROVIDES = ""
