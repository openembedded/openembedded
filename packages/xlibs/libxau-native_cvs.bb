SECTION = "x11/base"
include libxau_cvs.bb
inherit native
DEPENDS = "xproto-native"
PROVIDES = ""
