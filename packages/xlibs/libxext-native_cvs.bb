SECTION = "unknown"
include libxext_${PV}.bb
inherit native
DEPENDS = "libx11-native xextensions-native"
PROVIDES = ""
