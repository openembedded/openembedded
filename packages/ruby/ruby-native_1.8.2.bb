include ruby_${PV}.bb
inherit native
DEPENDS = ""
