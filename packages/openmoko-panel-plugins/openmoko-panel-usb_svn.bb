DESCRIPTION = "USB applet for the OpenMoko panel"
PV = "0.0.1+svn${SRCDATE}"

inherit openmoko-panel-plugin

