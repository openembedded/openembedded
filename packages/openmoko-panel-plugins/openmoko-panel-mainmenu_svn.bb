DESCRIPTION = "Main menu applet for the OpenMoko panel"
DEPENDS += "pulseaudio startup-notification"
PV = "0.1.0+svnr${SRCREV}"
PR = "r1"

inherit openmoko-panel-plugin

