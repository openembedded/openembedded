DESCRIPTION = "Shows the current time in the OpenMoko panel"
PV = "0.1.0+svnr${SRCREV}"

inherit openmoko-panel-plugin

