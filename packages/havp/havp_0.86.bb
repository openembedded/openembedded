require havp.inc

FILE_PR = "r1"

SRC_URI_append += " file://reconfigure.patch;patch=1"
