DEPENDS = "gst-plugins-base gst-plugins-good gst-plugins-ugly gst-plugins-bad"
PACKAGES_DYNAMIC = "gst-plugin-*"
