require gstreamer.inc
