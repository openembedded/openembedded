include gst-plugins.inc
DEPENDS += "gst-plugins-base"
