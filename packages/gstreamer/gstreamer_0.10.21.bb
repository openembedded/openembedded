require gstreamer_0.10.20.bb
SRC_URI += " file://disable_doc.patch;patch=1;pnum=1"
