require gstreamer.inc

PR = "r2"
