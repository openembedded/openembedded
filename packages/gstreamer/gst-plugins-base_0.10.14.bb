include gst-plugins.inc
PROVIDES_${PN} += "gst-plugins"
