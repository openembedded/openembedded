require gstreamer.inc

PR = "r1"