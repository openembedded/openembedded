require gst-plugins.inc

PR = "r2"
