require gst-plugins.inc

DEPENDS += "gst-plugins-base"
PR = "r2"
