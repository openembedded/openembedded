DESCRIPTION = "Task package: Enlightenment Foundation Libraries"
LICENSE = "MIT"
SECTION = "devel/efl"
RDEPENDS = "\
  eet \
  evas \
  ecore \
  embryo \
  edje \
  emotion \
  esmart \
  epsilon \
  edbus \
  efreet \
  ewl \
  etk \
  epdf \
"
FILE_PR = "r0"

ALLOW_EMPTY = "1"
