DESCRIPTION = "Games task package for GPE Palmtop Environment"
PR = "r5"
LICENSE = "MIT"
ALLOW_EMPTY = "1"

RDEPENDS = "\
    gpe-go \
    gpe-lights \
    gpe-othello \
    gpe-tetris \
    gsoko \
    xdemineur"

