DESCRIPTION = "Python Examples for the Enlightenment Foundation Libraries"
LICENSE = "MIT"
SECTION = "devel/python"
RDEPENDS = "\
  task-python-efl \
  python-ecore-examples \
  python-emotion-examples \
  python-edje-examples \
  python-etk-examples \
  python-epsilon-examples \
  python-math python-textutils \
"
FILE_PR = "ml4"

ALLOW_EMPTY = "1"
