DESCRIPTION = "Openmoko: Examples for the Openmoko Linux Distribution"
SECTION = "openmoko/base"
LICENSE = "MIT"
FILE_PR = "r71"

inherit task