DESCRIPTION = "SDK task for GPE Phone Edition"
PR = "r0"
LICENSE = "MIT"
ALLOW_EMPTY = "1"

RDEPENDS := "\
    libidn-dev \
    libim-dev \
    libgloox-dev \
    libabenabler-dev \
    libcalenebler-dev \
    libchenabler-dev \
    libgemwidget-dev \
    libiac-dev \
    liblips_im-dev \
    liblipsevent-dev \
    libmsgenabler-dev \
    librecord-dev \
    libvocenabler-dev \
    liblinphone-dev \
    "

