DESCRIPTION = "Settings task package for GPE Palmtop Environment"
PR = "r5"
LICENSE = "MIT"
ALLOW_EMPTY = "1"

RDEPENDS = "\
    gpe-mininet \
    gpe-bluetooth \
    gpe-beam \
    matchbox-panel-manager \
    gpe-su \
    gpe-conf \
    gpe-clock \
    gpe-mixer \
    gpe-package \
    gpe-shield \
    gpe-taskmanager \
    keylaunch \
    minilite \
    minimix \
    xmonobut"

