require task-sdk-host.bb

DESCRIPTION = "Packages for a standalone FSO SDK or external toolchain"
LICENSE = "MIT"
ALLOW_EMPTY = "1"

PR = "r0"

PACKAGES = "${PN}"
