HOMEPAGE = "http://www.trolltech.com"
LICENSE = "MIT"

inherit task

DESCRIPTION_task-qtopia-core-console = "QtopiaCore Core libraries for XML, SQL, Network, Containers and others."
RDEPENDS_task-qtopia-core-console = "\
    libqt-embeddedcore4 \
    libqt-embeddednetwork4 \
    libqt-embeddedxml4 \
    libqt-embeddedsql4"

    
