require gimp.inc

SRC_URI = "ftp://ftp.gimp.org/pub/gimp/v2.4/gimp-${PV}.tar.bz2 \
                 file://configure-libwmf.patch;patch=1"

