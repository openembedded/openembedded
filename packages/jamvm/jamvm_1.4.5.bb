require jamvm.inc

SRC_URI += "file://jamvm-1.3.1-size-defaults.patch;patch=1"

