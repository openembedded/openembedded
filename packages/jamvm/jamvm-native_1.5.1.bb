require jamvm-native.inc

FILE_PR = "r1"

