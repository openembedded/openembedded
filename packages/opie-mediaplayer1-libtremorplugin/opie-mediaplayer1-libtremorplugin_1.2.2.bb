require ${PN}.inc
FILE_PR = "r1"


SRC_URI = "${HANDHELDS_CVS};tag=${TAG};module=opie/core/multimedia/opieplayer \
	   file://vorbis.pro "
