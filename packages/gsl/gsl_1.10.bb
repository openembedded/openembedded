include gsl.inc

SRC_URI = "${GNU_MIRROR}/gsl/gsl-${PV}.tar.gz"
