require libxml2-native.inc
FILE_PR = "r0"
