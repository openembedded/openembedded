# You want this old version for compatibility with Maemo OS2008.
require libxml2.inc

