require qtnx.inc
inherit qt4x11
