require qtnx.inc
inherit qtopia4core
