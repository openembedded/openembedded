# This package builds the devio program for the build architecture
require devio_1.0.bb
require devio-native.inc
