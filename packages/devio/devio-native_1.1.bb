# This package builds the devio program for the build architecture
require devio_1.1.bb
require devio-native.inc
