UNSLUNG_VARIANT = "able"

include unslung-standard-rootfs_2.3r25.bb

# Add overlays and patches to the standard rootfs here
SRC_URI += ""

