#Empty recipe to break a recursive loop
DEFAULT_PREFERENCE = "-1"
DEFAULT_PREFERENCE_angstrom = "1"

#keep in sync with qt-embedded_4.4.0.bb
PR = "r4"
