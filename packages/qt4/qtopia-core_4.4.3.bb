#Empty recipe to break a recursive loop
DEFAULT_PREFERENCE = "-1"
DEFAULT_PREFERENCE_angstrom = "1"

#keep in sync with qt-embedded_${PV}.bb
PR = "r1"
