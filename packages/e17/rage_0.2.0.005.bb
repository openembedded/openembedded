DESCRIPTION = "Rage is a media center application based on EFL"
AUTHOR = "Carsten 'The Rasterman' Heitzler"
HOMEPAGE = "http://www.rasterman.com"
LICENSE = "GPL"
DEPENDS = "evas ecore edje"
SECTION = "x11/multimedia"

SRC_URI = "http://download.enlightenment.org/snapshots/2007-08-26/rage-${PV}.tar.gz"

inherit autotools

