require uicmoc4-native.inc

inherit native
