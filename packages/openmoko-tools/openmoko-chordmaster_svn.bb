DESCRIPTION = "A guitar chord database for Openmoko"
SECTION = "openmoko/tools"
PV = "0.0.1+svn${SRCDATE}"

inherit openmoko

