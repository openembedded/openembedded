DESCRIPTION = "The OpenMoko Application Manager"
SECTION = "openmoko/applications"
DEPENDS += "ipkg"
PV = "0.0.1+svnr${SRCREV}"

inherit openmoko

