DESCRIPTION = "The OpenMoko Calculator Application"
SECTION = "openmoko/applications"
AUTHOR = "Rodolphe Ortalo <rodolphe.ortalo@free.fr>"

PV = "0.0.3+svn${SRCDATE}"
PR = "r0"

inherit openmoko

