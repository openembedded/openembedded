DESCRIPTION = "The OpenMoko Footer"
SECTION = "openmoko/applications"
PV = "0.0.1+svn${SRCDATE}"

inherit openmoko

