DESCRIPTION = "The OpenMoko RSS Reader"
SECTION = "openmoko/applications"
DEPENDS += "libmrss"

PV = "0.0.1+svn${SRCDATE}"
PR = "r1"

inherit openmoko

