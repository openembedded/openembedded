require blueprobe.inc
