SECTION = "x11/network"
LICENSE = "GPL"
inherit gpe

