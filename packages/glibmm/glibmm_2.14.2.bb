require glibmm.inc

DEFAULT_PREFERENCE = "-1"
