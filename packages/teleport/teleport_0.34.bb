inherit gpe
LICENSE = "GPL"
DESCRIPTION = "Teleport app"
DEPENDS = "gtk+ libgpewidget libdisplaymigration libgcrypt sqlite"
MAINTAINER = "Koen Kooi  <koen@linuxtogo.org>"SECTION = "gpe"
PRIORITY = "optional"
