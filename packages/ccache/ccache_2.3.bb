HOMEPAGE = "http:/ccache.samba.org"
DESCRIPTION = "compiler cache"
SECTION = "devel"
LICENSE= "GPL"

SRC_URI = "http://ccache.samba.org/ftp/ccache/ccache-${PV}.tar.gz"

inherit autotools
