DESCRIPTION = "Conway's Game of Life for GPE"
LICENSE = "GPL"
PRIORITY = "optional"
SECTION = "gpe/games"
FILE_PR = "r1"

DEPENDS = "glib-2.0 gtk+ libglade"

inherit gpe autotools
