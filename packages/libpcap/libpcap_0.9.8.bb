require libpcap.inc

FILE_PR = "r3"

SRC_URI += "file://aclocal.patch;patch=1"
