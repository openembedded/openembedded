require libpcap.inc

PR = "r2"
