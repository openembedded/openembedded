require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- mouse input driver"
PE = "1"
