require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- i740 display driver"

PE = "1"
