require xorg-driver-input.inc
PE = "1"

DESCRIPTION = "The VMMouse driver enables support for the special VMMouse protocol \
that is provided by VMware virtual machines to give absolute pointer \
positioning. "

