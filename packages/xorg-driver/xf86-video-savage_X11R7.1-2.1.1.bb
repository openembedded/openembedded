include xorg-driver-video.inc

#DESCRIPTION = ""

DEPENDS += " drm xf86driproto"
