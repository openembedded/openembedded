require xorg-driver-input.inc
PE = "1"

DESCRIPTION = "X.Org X server -- Tek4957 input driver"
