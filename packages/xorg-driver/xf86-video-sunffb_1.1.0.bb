require xorg-driver-video.inc
PE = "1"

DEPENDS += " drm xf86driproto"
