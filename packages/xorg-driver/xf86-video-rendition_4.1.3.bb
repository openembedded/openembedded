require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X11 driver supporting cards based on the V1000 or the V2x00."

#DEPENDS += " "
