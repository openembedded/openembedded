require xorg-driver-video.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " drm xf86driproto libxvmc"
