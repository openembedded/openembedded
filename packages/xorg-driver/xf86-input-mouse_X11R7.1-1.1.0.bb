include xorg-driver-input.inc

DESCRIPTION = "Mouse Support in X11

#DEPENDS += " "

