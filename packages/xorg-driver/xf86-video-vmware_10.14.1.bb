require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X11 driver for VMware SVGA Device"

#DEPENDS += " "
