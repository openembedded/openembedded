require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- DMC input driver"
PE = "1"

