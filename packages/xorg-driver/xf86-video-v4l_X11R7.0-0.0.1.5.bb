require xorg-driver-video.inc

DESCRIPTION = "Video 4 Linux adaptor driver for X11"

#DEPENDS += " "
