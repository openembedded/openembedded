require xorg-driver-video.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " xf86dgaproto"
