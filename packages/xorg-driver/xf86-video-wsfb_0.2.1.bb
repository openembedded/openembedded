require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- wsfb display driver"
PE = "1"
