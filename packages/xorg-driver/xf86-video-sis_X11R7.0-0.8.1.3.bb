require xorg-driver-video.inc

#DESCRIPTION = ""

DEPENDS += " xineramaproto xf86miscproto xf86dgaproto drm xf86driproto"

