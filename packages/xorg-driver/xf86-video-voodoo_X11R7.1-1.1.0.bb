include xorg-driver-video.inc

DESCRIPTION = "X11 driver for Voodoo/Voodoo2"

DEPENDS += " xf86dgaproto"
