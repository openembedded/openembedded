require xorg-driver-video.inc

DESCRIPTION = "This is an unaccelerated driver for the SGI newport cards."

#DEPENDS += " "

