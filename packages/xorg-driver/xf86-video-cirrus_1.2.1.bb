require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X.Org X server -- Cirrus display driver"
