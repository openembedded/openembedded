require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "Number Nine I128 for X11"

#DEPENDS += " "
