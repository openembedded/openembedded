require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X.Org X server -- legacy S3 display driver"
