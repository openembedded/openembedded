require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "This is an unaccelerated driver for the SGI newport cards."

#DEPENDS += " "

