require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- joystick input driver"
PE = "1"
