require xorg-driver-video.inc

#DESCRIPTION = ""

#DEPENDS += " "

