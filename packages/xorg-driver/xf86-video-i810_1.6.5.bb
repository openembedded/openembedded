require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "I810 for X11"

DEPENDS += " virtual/libx11 libxvmc drm xf86driproto"

