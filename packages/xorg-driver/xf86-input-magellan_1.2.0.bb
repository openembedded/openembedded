require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- Magellan input driver"
PE = "1"
