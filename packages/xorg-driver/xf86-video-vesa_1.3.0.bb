require xorg-driver-video.inc
PE = "1"

SRC_URI += "file://fix-includepath.patch;patch=1"

#DESCRIPTION = ""

#DEPENDS += " "
