require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X.Org X server -- Chips display driver"
