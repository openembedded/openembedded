require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- AceCad input driver"
PE = "1"

