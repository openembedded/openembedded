require xorg-driver-video.inc

PE = "1"

DESCRIPTION = "Video 4 Linux adaptor driver for X11"
