require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- NV display driver"
PE = "1"
