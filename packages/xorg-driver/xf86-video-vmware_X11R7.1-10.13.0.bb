include xorg-driver-video.inc

DESCRIPTION = "X11 driver for VMware SVGA Device"

#DEPENDS += " "
