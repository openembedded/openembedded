require xorg-driver-video.inc

SRC_URI += "file://fix-includepath.patch;patch=1"

#DESCRIPTION = ""

#DEPENDS += " "
