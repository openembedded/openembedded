include xorg-driver-video.inc

#DESCRIPTION = ""

DEPENDS += " xineramaproto xf86miscproto drm xf86driproto"
