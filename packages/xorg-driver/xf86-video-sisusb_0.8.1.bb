require xorg-driver-video.inc

PE = "1"

DEPENDS += " xineramaproto xf86miscproto"

