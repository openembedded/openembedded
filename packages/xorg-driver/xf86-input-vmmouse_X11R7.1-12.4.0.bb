include xorg-driver-input.inc

DESCRIPTION = "The VMMouse driver enables support for the special VMMouse protocol \
that is provided by VMware virtual machines to give absolute pointer \
positioning. "

#DEPENDS += " "

