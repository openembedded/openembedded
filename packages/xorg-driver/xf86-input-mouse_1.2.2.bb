require xorg-driver-input.inc
PE = "1"

DESCRIPTION = "Mouse Support in X11"

#DEPENDS += " "

