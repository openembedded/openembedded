require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- Calcomp input driver"
PE = "1"
