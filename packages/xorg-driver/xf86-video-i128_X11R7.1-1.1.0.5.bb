include xorg-driver-video.inc

DESCRIPTION = "Number Nine I128 for X11"

#DEPENDS += " "
