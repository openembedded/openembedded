include xorg-driver-video.inc

#DESCRIPTION = ""

DEPENDS += " xf86dgaproto"
