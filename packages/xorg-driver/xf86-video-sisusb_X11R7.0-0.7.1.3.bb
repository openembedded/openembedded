require xorg-driver-video.inc

#DESCRIPTION = ""

DEPENDS += " xineramaproto xf86miscproto"

