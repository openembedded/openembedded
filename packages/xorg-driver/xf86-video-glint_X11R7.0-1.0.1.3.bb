require xorg-driver-video.inc

#DESCRIPTION = ""

DEPENDS += " xf86dgaproto drm xf86driproto"
