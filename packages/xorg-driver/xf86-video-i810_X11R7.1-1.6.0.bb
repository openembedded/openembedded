include xorg-driver-video.inc

DESCRIPTION = "I810 for X11"

DEPENDS += " virtual/x11 libxvmc drm xf86driproto"

