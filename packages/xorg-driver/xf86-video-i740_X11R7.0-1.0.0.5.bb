include xorg-driver-video.inc

DESCRIPTION = "I740 for X11"

#DEPENDS += " "
