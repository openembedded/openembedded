# This package builds tools to manage NIS
# The source package is utils/net/NIS/yp-tools
#
PR = "r0"
DESCRIPTION="\
Network Information Service tools.  \
This package contains ypcat, ypmatch, ypset, \
ypwhich, yppasswd, domainname, nisdomainname \
and ypdomainname."

include nis.inc
