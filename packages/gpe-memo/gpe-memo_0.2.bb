DESCRIPTION = "GPE Voice Notes Recorder"
SECTION = "gpe/multimedia"
PRIORITY = "optional"
LICENSE = "GPL"
DEPENDS = "gtk+ libgpewidget libgsm gpe-soundserver"

GPE_TARBALL_SUFFIX = "bz2"
inherit gpe autotools

