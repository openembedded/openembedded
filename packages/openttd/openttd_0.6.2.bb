require openttd.inc 

PR = "r0"

# When upgrading this recipe make sure to refresh this patch.
SRC_URI += "file://openttd_${PV}-buildfix.patch;patch=1"



