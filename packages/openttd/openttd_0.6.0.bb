require openttd.inc 

PR = "r2"

SRC_URI += "file://openttd_0.6.0-buildfix.patch;patch=1"



