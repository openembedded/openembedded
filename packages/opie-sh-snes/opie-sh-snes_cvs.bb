require ${PN}.inc

PV = "${OPIE_CVS_PV}"
FILE_PR = "r2"
