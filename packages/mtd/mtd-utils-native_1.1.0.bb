# scheduled to enable 15-03-2008
DEFAULT_PREFERENCE = "-1"

require mtd-utils_${PV}.bb
require mtd-utils-native.inc
