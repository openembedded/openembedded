SECTION = "console/utils"
include sed_${PV}.bb
inherit native
