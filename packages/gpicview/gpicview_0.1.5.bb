DESCRIPTION = "Extremely lightweight and fast with low memory usage"
LICENSE = "GPL"

DEPENDS = "gtk+"

SRC_URI = "${SOURCEFORGE_MIRROR}/lxde/${PN}-${PV}.tar.gz"

inherit autotools pkgconfig


