DESCRIPTION = "GUI/Project Manager for teh gEDA suite"
LICENSE = "GPLv2"
HOMEPAGE = "http://geda.seul.org"

DEPENDS = "libgeda gtk+"
RRECOMMENDS = "geda-utils geda-gattrib geda-gnetlist geda-gschem geda-gsymcheck geda-symbols geda-docs geda-examples"
