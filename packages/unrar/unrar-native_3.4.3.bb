require unrar.inc
inherit native

do_stage() {
    install unrar ${STAGING_BINDIR}
}

do_package() {
    :
}

do_install() {
    :
}
