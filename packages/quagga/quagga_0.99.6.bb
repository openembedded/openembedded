PR = "r2"

require quagga.inc

QUAGGASUBDIR = "/attic"