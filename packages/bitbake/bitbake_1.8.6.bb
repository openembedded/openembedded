require bitbake.inc

PR = "r0"

SRC_URI = "http://download.berlios.de/bitbake/bitbake-${PV}.tar.gz"

S = "${WORKDIR}/bitbake-${PV}"
