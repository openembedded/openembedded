DESCRIPTION = "Rodent vector icon theme used by XFCE"
PACKAGE_ARCH = "all"

inherit xfce

FILES_${PN} += "${datadir}/xfce4"
