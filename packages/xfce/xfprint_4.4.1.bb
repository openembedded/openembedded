# xfprint OE build file
# Copyright (C) 2004, Advanced Micro Devices, Inc.  All Rights Reserved
# Released under the MIT license (see packages/COPYING)

DESCRIPTION="XFCE4 Print Manager"
SECTION = "x11/base"

DEPENDS="libxfcegui4"
inherit xfce
