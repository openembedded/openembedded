DESCRIPTION = "Calendar application for the Xfce Desktop  Environment"
DEPENDS = "libxfcegui4 exo libxml-parser-perl-native xfce4-panel xfce-mcs-manager"
RREPLACES = "xfcalendar"

inherit xfce
