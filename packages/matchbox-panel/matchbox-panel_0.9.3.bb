include matchbox-panel.inc
DEFAULT_PREFERENCE = "-1"
PR="r0"
SRC_URI = "http://projects.o-hand.com/matchbox/sources/${PN}/0.9/${PN}-${PV}.tar.gz \        
	   file://mb-applet-battery-repaint-093.patch;patch=1"
