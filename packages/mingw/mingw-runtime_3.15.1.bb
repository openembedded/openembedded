require mingw-runtime.inc

PR = "r1"

SRC_URI = "${SOURCEFORGE_MIRROR}/mingw/mingwrt-${PV}-mingw32-src.tar.gz"

S = "${WORKDIR}/mingwrt-${PV}-mingw32"
