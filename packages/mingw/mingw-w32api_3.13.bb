require mingw-w32api.inc

PR = "r1"

SRC_URI = "${SOURCEFORGE_MIRROR}/mingw/w32api-${PV}-mingw32-src.tar.gz"

S = "${WORKDIR}/w32api-${PV}-mingw32"
