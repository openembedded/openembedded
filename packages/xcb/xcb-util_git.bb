DEFAULT_PREFERENCE = "-1"

include xcb-util.inc
PV = "0.2+git"
PR = "r0"

SRC_URI = "git://anongit.freedesktop.org/git/xcb;protocol=git"
S = "${WORKDIR}/git/xcb-util"
