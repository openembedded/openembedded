include libxcb.inc
FILE_PR = "r0"

DEPENDS += "libpthread-stubs"

PACKAGES =+ "libxcb-xinerama"
