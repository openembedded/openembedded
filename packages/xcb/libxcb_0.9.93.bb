include libxcb.inc
FILE_PR = "r2"

PACKAGES =+ "libxcb-xinerama"
