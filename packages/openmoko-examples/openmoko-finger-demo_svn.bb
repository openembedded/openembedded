DESCRIPTION = "An example finger application for OpenMoko"
SECTION = "openmoko/examples"
PV = "0.0.1+svn${SRCDATE}"

inherit openmoko

