LICENSE = "GPL"
SECTION = "unknown"
DESCRIPTION = "Regex-markup performs regular expression-based text \
markup according to used-defined rules."


SRC_URI = "http://savannah.nongnu.org/download/regex-markup/regex-markup-${PV}.tar.gz"

inherit autotools
