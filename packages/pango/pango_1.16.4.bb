DEFAULT_PREFERENCE = "-1"

require pango.inc

