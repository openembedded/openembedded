require pango.inc

DEFAULT_PREFERENCE = "-1"

