require pango.inc
FILE_PR = "r2"


