require gtk-sato-engine.inc

FILE_PR = "r4"

SRC_URI = "http://pokylinux.org/releases/sato/sato-engine-${PV}.tar.gz"
S = "${WORKDIR}/sato-engine-${PV}"
