require gpe-ownerinfo.inc

FILE_PR = "r0"
