require gpe-ownerinfo.inc

FILE_PR = "r1"

SRC_URI += "file://compile.patch;patch=1"
