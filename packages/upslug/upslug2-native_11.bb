include upslug2_${PV}.bb
inherit native
