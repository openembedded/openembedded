include upslug2_8.bb
inherit native
