include upslug2.inc

inherit native
