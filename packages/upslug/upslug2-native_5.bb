include upslug2_5.bb
inherit native
