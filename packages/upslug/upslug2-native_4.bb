include upslug2_4.bb
inherit native
