require angstrom-console-image.bb

ANGSTROM_EXTRA_INSTALL += " altboot "

export IMAGE_BASENAME = "altboot-console-image"

