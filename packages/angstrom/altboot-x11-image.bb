require x11-image.bb

ANGSTROM_EXTRA_INSTALL += " altboot "
export IMAGE_BASENAME = "altboot-x11-image"
