DESCRIPTION = "A graphical Boot Manager for the Ångström Linux Distribution"
AUTHOR = "Michael 'Mickey' Lauer <mickey@Vanille.de>"
MAINTAINER = "${AUTHOR}"
SECTION = "base"
DEPENDS = "evas-fb ecore-fb esmart-fb imlib2-fb edje efl++-fb"
RDEPENDS = "libefl++0"

ALLOW_EMPTY = "1"

#
# yes, this package doesn't do anything yet :D
#
