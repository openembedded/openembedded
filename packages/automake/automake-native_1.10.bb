PV := "${PV}"

require automake-native.inc

DEFAULT_PREFERENCE = "-1"
