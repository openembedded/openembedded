DESCRIPTION = "inotify-tools is a set of command line utilities for the \
Linux inotify filesystem change notification system."
LICENSE = "GPL"
AUTHOR = "Rohan McGovern"
HOMEPAGE = "http://rohanpm.net/inotify-tools"
MAINTAINER = "Michael 'Mickey' Lauer <mickey@Vanille.de>"
PR = "r0"

SRC_URI = "http://rohanpm.net/files/inotify-tools-2.1.tar.gz"

inherit autotools

