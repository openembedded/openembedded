DESCRIPTION = "Motion - a motion detection program"
HOMEPAGE = "http://www.lavrsen.dk/twiki/bin/view/Motion/WebHome"
PRIORITY = "optional"
PR = "r0"
LICENSE = "GPL"
DEPENDS = "jpeg"
PRIORITY = "optional"
MAINTAINER = "eFfeM <fransmeulenbroeks at yahoo dot com>"

SRC_URI = "${SOURCEFORGE_MIRROR}/motion/motion-3.2.6.tar.gz"

inherit autotools

