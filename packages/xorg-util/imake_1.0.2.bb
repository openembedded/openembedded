require xorg-util-common.inc

DESCRIPTION = "C preprocessor interface to the make utility"
RDEPENDS = "perl xproto"

FILE_PR = "r1"
PE = "1"
