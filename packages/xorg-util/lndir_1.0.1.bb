require xorg-util-common.inc

DESCRIPTION = "create a shadow directory of symbolic links to another directory tree"
FILE_PR = "r1"
PE = "1"
