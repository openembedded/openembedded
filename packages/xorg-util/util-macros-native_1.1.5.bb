require util-macros_${PV}.bb

inherit native

FILE_PR = "r1"

XORG_PN = "util-macros"

S = "${WORKDIR}/util-macros-1.1.5"
