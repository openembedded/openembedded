require xorg-util-common.inc

DESCRIPTION = "create dependencies in makefiles using 'gcc -M'"
RDEPENDS = "gcc"

FILE_PR = "r2"
PE = "1"
