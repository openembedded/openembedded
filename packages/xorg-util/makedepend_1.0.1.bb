require xorg-util-common.inc

DESCRIPTION = "create dependencies in makefiles"
DEPENDS = "xproto util-macros"
FILE_PR = "r2"
PE = "1"
