require tangogps.inc

DEPENDS += "sqlite3"
PR = "r1"
