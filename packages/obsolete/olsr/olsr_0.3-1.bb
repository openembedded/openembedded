LICENSE = "GPL"
SECTION = "console/network"
DESCRIPTION = "OLSR - routing protocol for wireless network"
PRIORITY = "optional"

SRC_URI = "ftp://ftp.tcweb.org/pub/tom/olsr-${PV}.tar.gz"

inherit autotools
