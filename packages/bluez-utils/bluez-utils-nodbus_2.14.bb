include bluez-utils-common_${PV}.inc
PR = "r1"

EXTRA_OECONF += "--without-dbus"

