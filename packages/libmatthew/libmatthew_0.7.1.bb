require libmatthew.inc

PR = "r0"

SRC_URI = "http://www.matthew.ath.cx/projects/java/libmatthew-java-${PV}.tar.gz \
           file://Makefile-0.7.patch;patch=1"


