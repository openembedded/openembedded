
# classpath-minimal-native has no packages
# primary goal is to speed up building of java virtual machines

inherit native

require classpath-minimal.inc

