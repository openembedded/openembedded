require xautomation.inc

FILE_PR = "r0"
