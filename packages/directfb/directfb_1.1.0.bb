require directfb.inc

RV = "1.1-0"
