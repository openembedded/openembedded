require libgpg-error.inc

PR = "r1"
