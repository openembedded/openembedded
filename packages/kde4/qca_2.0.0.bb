require kde4.inc

PV = "2.0.0"
SRC_URI = "svn://anonsvn.kde.org/home/kde/tags/qca;module=2.0.0;proto=svn"

S= "${WORKDIR}/2.0.0"

