PR = "r0"

require madwifi-ng_r.inc
