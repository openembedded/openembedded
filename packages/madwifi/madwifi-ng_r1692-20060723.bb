require madwifi-ng_r.inc
PR="r1"
