require php.inc
