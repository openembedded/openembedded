require psmisc.inc
FILE_PR = "r2"
SRC_URI += "file://signames-header-fix.patch;patch=1"
