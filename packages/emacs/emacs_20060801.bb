require emacs_cvs.bb
SRCDATE = "${PV}"
DEFAULT_PREFERENCE = "0"
