require emacs-x11_cvs.bb
SRCDATE = "${PV}"
DEFAULT_PREFERENCE = "0"
