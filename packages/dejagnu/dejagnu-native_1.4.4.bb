include dejagnu_${PV}.bb
S = "${WORKDIR}/dejagnu-${PV}"
inherit native

