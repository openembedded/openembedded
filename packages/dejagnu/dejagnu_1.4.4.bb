DESCRIPTION = "GNU unit testing framework, written in Expect and Tcl"
LICENSE = "GPL"
SECTION = "devel"
FILE_PR = "r1"

SRC_URI = "ftp://ftp.gnu.org/gnu/dejagnu/dejagnu-${PV}.tar.gz"

inherit autotools

