include ${PN}.inc
    
 

SRC_URI = "${HANDHELDS_CVS};tag=${TAG};module=opie/inputmethods/jumpx \
	   ${HANDHELDS_CVS};tag=${TAG};module=opie/pics"
