require dbus.inc
PR = "r13"

DEFAULT_PREFERENCE = "-1"
