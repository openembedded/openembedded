require anki.inc

FILE_PR = "r0"

S = "${WORKDIR}/anki-${PV}/libanki"
