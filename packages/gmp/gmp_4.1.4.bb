require gmp.inc

FILE_PR = "r1"

SRC_URI += "file://sh4-asmfix.patch;patch=1"