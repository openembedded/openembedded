require gpe-todo.inc

DEPENDS += "gtk+ libgpepimc"
