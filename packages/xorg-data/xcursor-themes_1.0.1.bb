require xorg-data-common.inc
PE = "1"

DEPENDS += " libxcursor"

