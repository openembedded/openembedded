include xorg-data-common.inc

#DESCRIPTION = ""

#DEPENDS += " "
RDEPENDS = "xkbcomp"

FILES_${PN} += " /usr/share/X11/xkb"

