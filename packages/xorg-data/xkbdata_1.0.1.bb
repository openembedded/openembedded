require xorg-data-common.inc
PE = "1"

RDEPENDS = "xkbcomp"

FILES_${PN} += " /usr/share/X11/xkb"

