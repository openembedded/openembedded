include xorg-data-common.inc

#DESCRIPTION = ""

DEPENDS += " libxcursor"

