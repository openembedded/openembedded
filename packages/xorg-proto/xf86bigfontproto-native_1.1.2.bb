require xf86bigfontproto_${PV}.bb

FILE_PR = "r1"

XORG_PN = "xf86bigfontproto"

inherit native
