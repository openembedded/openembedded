require xorg-proto-common.inc

FILE_PR = "r1"
PE = "1"

XORG_PN = "xproto"
