require xorg-proto-common.inc

CONFLICTS = "xxf86dgaext"
FILE_PR = "r1"
PE = "1"
