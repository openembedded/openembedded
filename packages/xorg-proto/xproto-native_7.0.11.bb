require xproto_${PV}.bb

XORG_PN = "xproto"

inherit native
