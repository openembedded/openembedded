require xorg-proto-common.inc

CONFLICTS = "recordext"
FILE_PR = "r1"
PE = "1"
