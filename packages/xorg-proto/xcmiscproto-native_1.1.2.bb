require xcmiscproto_${PV}.bb

FILE_PR = "r1"

XORG_PN = "xcmiscproto"

inherit native
