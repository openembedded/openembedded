require kbproto_${PV}.bb

FILE_PR = "r1"

XORG_PN = "kbproto"

inherit native
