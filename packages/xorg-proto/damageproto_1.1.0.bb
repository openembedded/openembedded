require xorg-proto-common.inc

CONFLICTS = "damageext"
FILE_PR = "r1"
PE = "1"

XORG_PN = "damageproto"
