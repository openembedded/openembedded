require xorg-proto-common.inc

CONFLICTS = "renderext"
FILE_PR = "r1"
PE = "1"

XORG_PN = "renderproto"
