require fixesproto_${PV}.bb

PR = "r1"

XORG_PN = "fixesproto"

inherit native
