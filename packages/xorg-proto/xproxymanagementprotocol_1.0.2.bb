require xorg-proto-common.inc

PROVIDES="xproxymngproto"
FILE_PR = "r1"
PE = "1"
