require xorg-proto-common.inc
DESCRIPTION = "X11 OpenGL extension wire protocol"
PE = "1"
