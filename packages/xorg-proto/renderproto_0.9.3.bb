require xorg-proto-common.inc

CONFLICTS = "renderext"
PE = "1"

DEFAULT_PREFERENCE = "-1"
