require xorg-proto-common.inc

CONFLICTS = "xxf86vmext"
FILE_PR = "r1"
PE = "1"
