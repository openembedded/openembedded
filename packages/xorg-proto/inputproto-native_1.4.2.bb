require inputproto_${PV}.bb

FILE_PR = "r1"

XORG_PN = "inputproto"

inherit native
