require xorg-proto-common.inc

CONFLICTS = "fixesext"
FILE_PR = "r1"
PE = "1"

XORG_PN = "fixesproto"
