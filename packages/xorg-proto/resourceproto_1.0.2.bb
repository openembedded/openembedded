require xorg-proto-common.inc

CONFLICTS = "resourceext"
FILE_PR = "r1"
PE = "1"
