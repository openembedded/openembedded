include xorg-proto-common.inc

PROVIDES = "xextensions"

#DESCRIPTION = ""

#DEPENDS += " "
