require fontcacheproto_${PV}.bb

FILE_PR = "r1"

XORG_PN = "fontcacheproto"

inherit native
