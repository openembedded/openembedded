require bigreqsproto_${PV}.bb

FILE_PR = "r1"

XORG_PN = "bigreqsproto"

inherit native
