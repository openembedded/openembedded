require fontsproto_${PV}.bb

FILE_PR = "r1"

XORG_PN = "fontsproto"

S = "${WORKDIR}/fontsproto-${PV}"

inherit native
