require xextproto_${PV}.bb

FILE_PR = "r1"

XORG_PN = "xextproto"

inherit native
