require xorg-proto-common.inc

CONFLICTS = "randrext"
FILE_PR = "r1"
PE = "1"

XORG_PN = "randrproto"
