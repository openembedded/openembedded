require xproto_${PV}.bb

FILE_PR = "r1"

XORG_PN = "xproto"

inherit native
