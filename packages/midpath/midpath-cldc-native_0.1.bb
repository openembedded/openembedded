
inherit native

require midpath-cldc_${PV}.bb


PACKAGES = "${PN}-dbg  "

do_install() {
	:
}
