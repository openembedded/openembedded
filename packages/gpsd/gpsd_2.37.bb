require gpsd.inc

PR = "r0"
