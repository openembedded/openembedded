require gpsd.inc

PR = "r9.02"

