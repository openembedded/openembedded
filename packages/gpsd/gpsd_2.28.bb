require gpsd.inc
PR = "r3"
