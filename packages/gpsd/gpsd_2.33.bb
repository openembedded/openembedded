require gpsd.inc

DEPENDS = "ncurses"

PR = "r0"
