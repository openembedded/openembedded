include gpsd.inc
PR = "r0"
