require gcc-csl-arm-2005q3.inc
require gcc-package-target.inc
require gcc-cross.inc
PR = "r2"

# cross build
require gcc3-build-cross.inc
# cross packaging
require gcc-package-cross.inc
