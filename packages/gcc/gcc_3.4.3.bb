PR = "r12"

require gcc-${PV}.inc
require gcc-package-target.inc
