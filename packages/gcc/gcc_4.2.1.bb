require gcc-${PV}.inc
require gcc-package-target.inc
