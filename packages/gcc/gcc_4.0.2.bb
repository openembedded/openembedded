PR = "r7"

require gcc-${PV}.inc
require gcc-package-target.inc
