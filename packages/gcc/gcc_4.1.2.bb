PR = "r11"

require gcc-${PV}.inc
require gcc-package-target.inc
