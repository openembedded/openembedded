require gcc-${PV}.inc
require gcc-native.inc
PROVIDES += "gcc3-native"
