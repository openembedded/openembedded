PR = "r3"

require gcc-${PV}.inc
require gcc-package-target.inc
