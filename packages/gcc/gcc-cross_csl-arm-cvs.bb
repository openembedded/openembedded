require gcc-csl-arm-cvs.inc
require gcc-package-target.inc
require gcc-cross.inc
PR = "r1"

# cross build
require gcc3-build-cross.inc
# cross packaging
require gcc-package-cross.inc
