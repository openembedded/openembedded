require llvm.inc

SRC_URI = "http://llvm.org/releases/2.0/llvm-${PV}.tar.gz"

S = "${WORKDIR}/llvm-${PV}"

