include xorg-font-common.inc

DESCRIPTION = "Adobe typeface software"

#DEPENDS += " "

