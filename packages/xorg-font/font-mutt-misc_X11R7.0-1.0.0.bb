include xorg-font-common.inc

DESCRIPTION = "Provides a 12pt, 100dpi proportional font with many of \
the glyphs needed for Unicode text."

#DEPENDS += " "

