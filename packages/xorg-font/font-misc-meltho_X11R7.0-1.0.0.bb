include xorg-font-common.inc

DESCRIPTION = "These fonts are designed for the display of Syriac text."

#DEPENDS += " "

