require xorg-font-common.inc

DESCRIPTION = "100dpi, 24 point (approximately) font to minimally support (almost) all \
of the Arabic characters available in Unicode."

#DEPENDS += " "

