include xorg-font-common.inc

DESCRIPTION = "X font aliases."

DEPENDS = "virtual/xserver font-util"
RDEPENDS = "encodings font-util"

