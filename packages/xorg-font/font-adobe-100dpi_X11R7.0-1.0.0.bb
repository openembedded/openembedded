require xorg-font-common.inc

#DESCRIPTION = ""

#DEPENDS += " "

