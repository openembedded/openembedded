require xorg-font-common.inc

#DESCRIPTION = ""

DEPENDS = "mkfontscale-native"
RDEPENDS = ""

