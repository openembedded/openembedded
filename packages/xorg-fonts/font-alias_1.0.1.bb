include font-common.inc

DEPENDS = "mkfontscale"
FILES_${PN} = "${libdir}/X11/fonts/*"
