include font-common.inc

DEPENDS = "bdftopcf font-util"
FILES_${PN} = "${libdir}/X11/fonts/*"
