require mdadm.inc
FILE_PR = "r3"

SRC_URI += " file://build_flags.patch;patch=1 "
