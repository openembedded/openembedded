require libecj-bootstrap.inc

# Something is wrong with this ECJ version. It randomly fails to create directories.
DEFAULT_PREFERENCE = "-1"

SRC_URI = "\
	http://mirrors.ibiblio.org/pub/mirrors/eclipse/eclipse/downloads/drops/R-3.4-200806172000/ecjsrc.zip \
  "

