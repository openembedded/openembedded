require qtopia-phone.inc
