include uboot_cvs.bb

UBOOT_MACHINE = "pxa255_idp_config"
SRC_URI += "ftp://bec-systems.com/pub/pxa255_idp/u-boot/uboot_pxa255-idp_2005-03-02.patch;patch=1"
