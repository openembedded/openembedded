require xapian-quickstart.inc

DESCRIPTION += "This package provides the tool for searching the index."
FILE_PR = "r1"
