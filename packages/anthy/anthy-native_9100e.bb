require anthy_${PV}.bb

DEPENDS = ""
PACKAGES = ""
FILE_PR = "r1"

S = "${WORKDIR}/anthy-${PV}"

inherit native
