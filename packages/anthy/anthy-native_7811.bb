require anthy_${PV}.bb
PACKAGES = ""
DEPENDS = ""
inherit native
