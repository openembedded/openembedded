require hildon-thumbnail.inc

DEPENDS = "libhildon libosso"

PR = "r0"

SRC_URI = "http://repository.maemo.org/pool/maemo4.0/free/source/h/${PN}/${PN}_${PV}.tar.gz \
          "


