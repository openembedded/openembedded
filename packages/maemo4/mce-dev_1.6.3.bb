require mce-dev.inc

FILE_PR = "r0"

SRC_URI = "http://repository.maemo.org/pool/maemo4.0/free/source/m/mce-dev/mce-dev_${PV}.tar.gz"


