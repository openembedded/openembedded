require osso-gwconnect.inc

DEPENDS += "libhildon bluez-libs"

FILE_PR = "r0"

SRC_URI = "http://repository.maemo.org/pool/maemo4.0/free/source/o/${PN}/${PN}_${PV}.tar.gz"

