require libhildonhelp.inc

FILE_PR = "r0"

SRC_URI = "http://repository.maemo.org/pool/maemo4.0/free/source/libh/${PN}/${PN}_${PV}-1.tar.gz"

