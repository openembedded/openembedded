SRC_URI = "${HANDHELDS_CVS};tag=${TAG};module=opie/noncore/net/opietooth/lib"
PR = "r0"

require libopietooth1.inc
