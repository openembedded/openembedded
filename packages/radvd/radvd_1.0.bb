PR = "r1"

require radvd.inc

MD5SUM = "8bce4a21757cf069f5a69e2f9bee9e5b"
