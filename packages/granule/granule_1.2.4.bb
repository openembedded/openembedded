require granule.inc

SRC_URI = "${SOURCEFORGE_MIRROR}/${PN}/${PN}-${PV}-1.tar.gz"

