require ${PN}.inc
FILE_PR = "r1"



SRC_URI = "${HANDHELDS_CVS};tag=${TAG};module=opie/noncore/net/mail/libmailwrapper "
