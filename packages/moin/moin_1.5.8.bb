DESCRIPTION = "A full fledged WikiWiki system written in Python"
LICENSE = "GPL"
SECTION = "network"
HOMEPAGE = "http://moinmoin.wikiwikiweb.de/"
PRIORITY = "optional"
PR = "ml0"

SRC_URI = "${SOURCEFORGE_MIRROR}/moin/moin-${PV}.tar.gz"

inherit distutils

