PR = "r1"

require om-maps.inc

MAP_NAME = "Hong Kong"
MAP_FN = "om-maps-hong-kong-${PV}.eet"
MAP_VER = "${PV}"
