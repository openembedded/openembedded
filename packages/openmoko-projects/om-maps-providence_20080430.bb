PR = "r0"

require om-maps.inc

MAP_NAME = "Providence"
MAP_FN = "om-maps-providence-${PV}.eet"
MAP_VER = "${PV}"
