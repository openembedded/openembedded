PR = "r0"

require diversity-maps.inc

MAP_NAME = "Taipei"
MAP_FN = "taipei.eet"
MAP_VER = "${PV}"
