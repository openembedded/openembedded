PR = "r1"

require om-maps.inc

MAP_NAME = "Paris"
MAP_FN = "om-maps-paris-${PV}.eet"
MAP_VER = "${PV}"
