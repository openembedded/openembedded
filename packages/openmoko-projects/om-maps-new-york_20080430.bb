PR = "r0"

require om-maps.inc

MAP_NAME = "New York"
MAP_FN = "om-maps-new-york-${PV}.eet"
MAP_VER = "${PV}"
