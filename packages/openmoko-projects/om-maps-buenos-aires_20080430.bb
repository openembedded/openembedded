PR = "r1"

require om-maps.inc

MAP_NAME = "Buenos Aires"
MAP_FN = "om-maps-buenos-aires-${PV}.eet"
MAP_VER = "${PV}"
