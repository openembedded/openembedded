PR = "r1"

require om-maps.inc

MAP_NAME = "Sydney"
MAP_FN = "om-maps-sydney-${PV}.eet"
MAP_VER = "${PV}"
