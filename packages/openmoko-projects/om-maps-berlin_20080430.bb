PR = "r2"

MAP_NAME = "Berlin"
require om-maps.inc

MAP_FN = "om-maps-berlin-${PV}.eet"
MAP_VER = "${PV}"
