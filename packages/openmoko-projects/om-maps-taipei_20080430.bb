PR = "r1"

require om-maps.inc

MAP_NAME = "Taipei"
MAP_FN = "om-maps-taipei-${PV}.eet"
MAP_VER = "${PV}"
