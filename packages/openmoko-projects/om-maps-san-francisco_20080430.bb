PR = "r1"

require om-maps.inc

MAP_NAME = "San Francisco"
MAP_FN = "om-maps-san-francisco-${PV}.eet"
MAP_VER = "${PV}"
