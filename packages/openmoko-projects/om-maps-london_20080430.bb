PR = "r2"

MAP_NAME = "London"
require om-maps.inc

MAP_FN = "om-maps-london-${PV}.eet"
MAP_VER = "${PV}"
