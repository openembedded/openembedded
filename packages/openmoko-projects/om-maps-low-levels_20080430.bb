PR = "r1"

MAP_NAME = "low levels"
require om-maps.inc


MAP_FN = "om-maps-low-levels-${PV}.eet"
MAP_VER = "${PV}"
