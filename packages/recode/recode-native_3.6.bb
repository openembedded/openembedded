include recode_${PV}.bb

inherit native

S = "${WORKDIR}/recode-${PV}/"
