require rsync.inc

FILE_PR = "r3"

SRC_URI += "file://rsyncd.conf"
