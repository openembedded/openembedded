require gnome-doc-utils.inc

FILE_PR = "r1"
