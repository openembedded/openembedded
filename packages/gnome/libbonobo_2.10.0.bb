require libbonobo.inc

FILE_PR = "r2"
