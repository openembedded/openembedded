LICENSE = "GPL"
inherit gnome

DEPENDS += "intltool-native"
RDEPENDS = "shared-mime-info"

PR = "r2"
