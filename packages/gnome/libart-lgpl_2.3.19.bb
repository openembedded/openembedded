require libart-lgpl.inc

FILE_PR = "r2"
