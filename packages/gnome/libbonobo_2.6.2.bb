require libbonobo.inc

PR = "r2"
