require gnome-doc-utils.inc

PR = "r0"
