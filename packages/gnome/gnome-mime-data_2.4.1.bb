LICENSE = "GPL"
inherit gnome

DEPENDS += "intltool-native"
FILE_PR = "r1"
