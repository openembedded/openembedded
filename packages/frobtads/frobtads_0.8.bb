DESCRIPTION = "A TADS interpreter."
HOMEPAGE = "http://www.tads.org
SECTION = "console/network"

SRC_URI = "http://www.tads.org/frobtads/${PN}-${PV}.tar.gz"

inherit autotools
