require iqnotes.inc

PR = "r5"

SRC_URI = "http://www.vanille.de/mirror/iqnotes-2.0.2-src.tar.bz2 \
           file://md5.diff;patch=1 \
           file://qt2310-fontbug.patch;patch=1"
