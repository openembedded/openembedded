PV = "2.0.1+cvs-${CVSDATE}"

DEFAULT_PREFERENCE = "-1"

SRC_URI = "cvs://anonymous:@cvs.sourceforge.net/cvsroot/kdepimpi;module=kdepim "

include kdepimpi-base.inc
