PR = "r1"
SRC_URI = "${SOURCEFORGE_MIRROR}/kdepimpi/kdepimpi-${PV}.tar.gz "

include kdepimpi-base.inc
