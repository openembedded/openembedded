require gnuradio.inc

PR = "r4"

SRC_URI = "ftp://ftp.gnu.org/gnu/gnuradio/gnuradio-${PV}.tar.gz \
	   file://no-trellis-doc.patch;patch=1 \
	   "

