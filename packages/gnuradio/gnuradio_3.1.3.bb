require gnuradio.inc

PR = "r3"

SRC_URI = "ftp://ftp.gnu.org/gnu/gnuradio/gnuradio-${PV}.tar.gz \
#           file://gnuradio-libusb.patch;patch=1 \
	   file://acinclude.m4"

