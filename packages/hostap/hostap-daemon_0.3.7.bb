require hostap-daemon.inc

PR = "r1"
