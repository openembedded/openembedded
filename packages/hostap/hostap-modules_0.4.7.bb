require hostap-modules.inc
FILE_PR = "r5"

SRC_URI += "file://kernel_updates.patch;patch=1"
