require hostap-daemon.inc

FILE_PR = "r2"
