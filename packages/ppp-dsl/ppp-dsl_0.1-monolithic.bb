include ppp-dsl_0.1.bb

RDEPENDS = "ppp rp-pppoe"

S = "${WORKDIR}/ppp-dsl-0.1"
