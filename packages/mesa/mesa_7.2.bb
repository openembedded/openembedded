# This is a dummy package so OE can use the poky mesa files
require mesa-xlib_${PV}.bb
