include obexpush_${PV}.bb
inherit native

FILESPATH = "${FILE_DIRNAME}/obexpush-${PV}:${FILE_DIRNAME}/obexpush:${FILE_DIRNAME}/files:${FILE_DIRNAME}"

do_stage() {
	:
}

do_install() {
	:
}

