require dates.inc

PR = "r3"

SRC_URI = "http://projects.o-hand.com/sources/dates/dates-${PV}.tar.gz"
