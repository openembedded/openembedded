require dates.inc

FILE_PR ="r2"

SRC_URI = "http://pimlico-project.org/sources/dates/dates-${PV}.tar.gz \
	   file://dates-owl-window-menu.patch;patch=1 \
	  "
