require dates.inc

PR = "r0"

SRC_URI = "http://projects.o-hand.com/sources/dates/dates-${PV}.tar.gz"
