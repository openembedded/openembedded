require tasks.inc

PR = "r0"

SRC_URI = "http://pimlico-project.org/sources/${PN}/${P}.tar.gz"
