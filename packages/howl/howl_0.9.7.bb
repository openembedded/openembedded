SRC_URI = "http://www.porchdogsoft.com/download/howl-${PV}.tar.gz"
LICENSE = "howl"

inherit autotools

