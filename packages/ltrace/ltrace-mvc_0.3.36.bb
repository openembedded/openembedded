require ltrace_${PV}.bb

DEFAULT_PREFERENCE = "-1"

SRC_URI += "file://mvc-toolchain.patch;patch=1"
