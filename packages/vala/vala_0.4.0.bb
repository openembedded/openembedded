require vala.inc

SRC_URI = "http://download.gnome.org/sources/vala/0.4/vala-${PV}.tar.bz2"

