require vala_${PV}.bb
PR = "r0"

inherit native
DEPENDS = "glib-2.0-native"
