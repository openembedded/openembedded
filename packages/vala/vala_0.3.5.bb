
require vala.inc

SRC_URI = "http://download.gnome.org/sources/vala/0.3/vala-${PV}.tar.bz2"

