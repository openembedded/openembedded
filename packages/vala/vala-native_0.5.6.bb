require vala_${PV}.bb
PR = "r1"

inherit native
DEPENDS = "glib-2.0-native"
