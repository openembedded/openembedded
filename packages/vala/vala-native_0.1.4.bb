require vala_${PV}.bb

inherit native
DEPENDS = "glib-native-2.0"

