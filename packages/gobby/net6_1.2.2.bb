LICENSE = "LGPL"
HOMEPAGE = "http://darcs.0x539.de/trac/obby/cgi-bin/trac.cgi/wiki/"
MAINTAINER = "Koen Kooi <koen@handhelds.org>"

DEPENDS = "libsigc++-2.0"
inherit autotools pkgconfig

SRC_URI = "http://releases.0x539.de/${PN}/${P}.tar.gz"


