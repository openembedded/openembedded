require gpgme.inc

FILE_PR = "r4"
