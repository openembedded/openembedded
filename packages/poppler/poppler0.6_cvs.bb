require poppler.inc
PV = "0.5.9+cvs${SRCDATE}"
PR = "r1"

SRC_URI = "cvs://anoncvs@cvs.freedesktop.org/cvs/poppler;module=poppler"
S = "${WORKDIR}/poppler"
