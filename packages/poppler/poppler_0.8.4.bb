require poppler.inc

FILE_PR = "r0"

EXTRA_OECONF_append = " --disable-abiword-output "

