DESCRIPTION = "Metapackage for Matchbox suite"
LICENSE = "GPL"
RDEPENDS = "matchbox-common matchbox-wm matchbox-panel matchbox-desktop"
SECTION = "x11/wm"
FILE_PR = "r1"

ALLOW_EMPTY = "1"
