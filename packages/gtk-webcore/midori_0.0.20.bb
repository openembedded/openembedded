require midori.inc

SRC_URI = "http://goodies.xfce.org/releases/midori/midori-${PV}.tar.bz2"


