require midori.inc

SRC_URI = "http://software.twotoasts.de/media/midori/midori-${PV}.tar.bz2"


