require midori.inc

FILE_PR = "r2"

SRC_URI += "file://desktop.patch;patch=1"

