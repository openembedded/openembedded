require webkit-qt.inc
inherit qt4e

WEBKIT_EXTRA_OPTIONS += "QT+=xml QT+=network"

