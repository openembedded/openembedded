require webkit-qt.inc
inherit qt4x11

PR = "r1"
