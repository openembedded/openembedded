require acpid.inc
FILE_PR = "r2"

