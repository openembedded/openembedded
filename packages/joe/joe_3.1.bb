SECTION = "console/utils"
DESCRIPTION = "Joe's own editor."
LICENSE ="GPL"
SRC_URI = "${SOURCEFORGE_MIRROR}/joe-editor/joe-${PV}.tar.gz"

inherit autotools
