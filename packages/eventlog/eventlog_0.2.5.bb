DESCRIPTION = "Replacement syslog API"
LICENSE = "BSD"
PR = "r0"

SRC_URI = "http://www.balabit.com/downloads/syslog-ng/2.0/src/${PN}-${PV}.tar.gz"

inherit autotools

