SECTION = "libs"

inherit native

include libintl-perl_${PV}.bb
