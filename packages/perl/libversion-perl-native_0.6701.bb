SECTION = "libs"

inherit native

require libversion-perl_${PV}.bb
