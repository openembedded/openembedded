SECTION = "libs"

inherit native

require libmime-lite-perl_${PV}.bb
