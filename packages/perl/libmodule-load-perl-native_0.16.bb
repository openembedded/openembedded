SECTION = "libs"

inherit native

require libmodule-load-perl_${PV}.bb
