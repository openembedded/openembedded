SECTION = "libs"

inherit native

require libextutils-parsexs-perl_${PV}.bb
