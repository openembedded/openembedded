SECTION = "libs"

include libintl-perl_1.11.bb

inherit native
