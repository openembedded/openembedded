SECTION = "libs"

inherit native

require libexception-class-perl_${PV}.bb
