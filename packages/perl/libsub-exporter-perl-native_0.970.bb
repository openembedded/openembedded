SECTION = "libs"

inherit native

require libsub-exporter-perl_${PV}.bb
