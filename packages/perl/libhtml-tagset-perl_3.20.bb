DESCRIPTION = "HTML Tagset bits."
SECTION = "libs"
LICENSE = "Artistic|GPL"
PR = "r0"

SRC_URI = "http://search.cpan.org/CPAN/authors/id/P/PE/PETDANCE/HTML-Tagset-3.20.tar.gz"

S = "${WORKDIR}/HTML-Tagset-${PV}"

inherit cpan
