SECTION = "libs"

inherit native

require libx10-perl_${PV}.bb
