SECTION = "libs"

inherit native

require libparams-validate-perl_${PV}.bb
