SECTION = "libs"

inherit native

require libparams-util-perl_${PV}.bb
