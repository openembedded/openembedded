SECTION = "libs"

inherit native

require libdate-manip-perl_${PV}.bb
