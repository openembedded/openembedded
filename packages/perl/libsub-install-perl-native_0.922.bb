SECTION = "libs"

inherit native

require libsub-install-perl_${PV}.bb
