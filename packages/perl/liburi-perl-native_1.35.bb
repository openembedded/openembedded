inherit native
require liburi-perl_${PV}.bb
