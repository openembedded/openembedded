SECTION = "libs"

require libxml-twig-perl_${PV}.bb

inherit native

