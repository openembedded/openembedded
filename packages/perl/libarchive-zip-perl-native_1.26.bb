SECTION = "libs"

inherit native

require libarchive-zip-perl_${PV}.bb
