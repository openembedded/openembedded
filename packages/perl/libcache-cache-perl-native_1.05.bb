SECTION = "libs"

inherit native

require libcache-cache-perl_${PV}.bb
