SECTION = "libs"

inherit native

require libipc-sharelite-perl_${PV}.bb
