SECTION = "libs"

inherit native

require libsub-uplevel-perl_${PV}.bb
