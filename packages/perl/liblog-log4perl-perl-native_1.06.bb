SECTION = "libs"

inherit native

require liblog-log4perl-perl_${PV}.bb
