require libmatchbox.inc

PR = "r1"

SRC_URI = "http://projects.o-hand.com/matchbox/sources/libmatchbox/${PV}/libmatchbox-${PV}.tar.bz2 \
	   file://autofoo.patch;patch=1"
