SECTION = "gpe"
DESCRIPTION = "GPE application launcher"
DEPENDS = "libgpewidget libgpelaunch cairo"
MAINTAINER = "Phil Blundell <pb@handhelds.org>"
LICENSE = "GPL"
PR = "r0"

inherit gpe

