require exalt.inc

DEPENDS = "ecore etk edbus libexalt libexalt-dbus"
RDEPENDS_${PN} = "exalt-daemon"
