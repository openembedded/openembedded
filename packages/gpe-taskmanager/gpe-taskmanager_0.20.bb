DESCRIPTION = "GPE task manager"
SECTION = "gpe"
LICENSE = "GPL"
DEPENDS = "libgpelaunch libgpewidget"

inherit gpe


