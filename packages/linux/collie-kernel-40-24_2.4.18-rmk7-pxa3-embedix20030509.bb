COLLIE_MEMORY_SIZE=40
COLLIE_RAMDISK_SIZE=24

include ../linux/openzaurus-sa_2.4.18-rmk7-pxa3-embedix20030509.bb
