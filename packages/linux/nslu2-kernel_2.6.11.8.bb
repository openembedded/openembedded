# Kernel for NSLU2
PR = "r0"
include nslu2-kernel.inc
