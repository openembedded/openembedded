require linux-gta01_2.6.17.14.bb
