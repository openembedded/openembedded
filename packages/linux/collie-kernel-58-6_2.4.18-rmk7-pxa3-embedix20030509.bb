COLLIE_MEMORY_SIZE=58
COLLIE_RAMDISK_SIZE=6

include ../linux/openzaurus-sa_2.4.18-rmk7-pxa3-embedix20030509.bb
