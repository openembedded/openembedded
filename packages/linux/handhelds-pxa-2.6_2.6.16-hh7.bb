SECTION = "kernel"
DESCRIPTION = "handhelds.org Linux kernel for PXA based devices."
LICENSE = "GPL"
PR = "r1"

DEFAULT_PREFERENCE = "-1"

require handhelds-pxa-2.6.inc
