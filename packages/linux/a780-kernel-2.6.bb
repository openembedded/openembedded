MACHINE = "a780"
require linux-ezx_2.6.16.13.bb
