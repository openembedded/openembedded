MACHINE = "e680"
COMPATIBLE_MACHINE = "(e680|a780)"
require linux-ezx_2.6.16.13.bb
