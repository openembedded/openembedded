COMPATIBLE_MACHINE = "a780"
PROVIDES = "virtual/kernel"
DEPENDS = "a780-kernel-2.6 e680-kernel-2.6"
