COLLIE_MEMORY_SIZE = "24"
COLLIE_RAMDISK_SIZE = "8"

require ../linux/openzaurus-sa_2.4.18-rmk7-pxa3-embedix20030509.bb
