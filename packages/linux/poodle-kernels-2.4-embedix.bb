COMPATIBLE_MACHINE = "poodle"
COMPATIBLE_HOST = "arm.*-linux"
DEPENDS = "poodle-kernel-2.4-embedix poodle255-kernel-2.4-embedix"
