MACHINE = "e680"
require linux-ezx_2.6.16.13.bb
