include bluez-utils.inc

PR = "r1"

EXTRA_OECONF += "--without-dbus"

