require bluez-libs.inc

PR = "r1"

