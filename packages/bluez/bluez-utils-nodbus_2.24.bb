require bluez-utils.inc

PR = "r3"

EXTRA_OECONF += "--without-dbus"
