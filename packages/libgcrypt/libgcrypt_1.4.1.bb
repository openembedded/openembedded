require libgcrypt.inc

