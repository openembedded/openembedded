require libgcrypt.inc

FILE_PR = "r2"
