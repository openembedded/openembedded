include ${PN}.inc
    
 

SRC_URI = "${HANDHELDS_CVS};tag=${TAG};module=opie/core/pim/datebook/holiday/national \
           ${HANDHELDS_CVS};tag=${TAG};module=opie/etc/nationaldays "
