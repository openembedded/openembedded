include app-common.inc
DEPENDS = "libx11 twm xclock xeyes xrdb"
