require xorg-app-common.inc

DESCRIPTION = "window information utility for X"
DEPENDS += " libxmu libxext virtual/libx11"
PE = "1"
