require xorg-app-common.inc
PE = "1"

DESCRIPTION = "a property displayer for X"

DEPENDS += " libxmu virtual/libx11"
