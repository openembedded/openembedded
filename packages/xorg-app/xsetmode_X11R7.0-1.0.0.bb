require xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxi virtual/libx11"

