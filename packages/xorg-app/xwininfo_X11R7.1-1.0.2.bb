include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxmu libxext virtual/libx11"

