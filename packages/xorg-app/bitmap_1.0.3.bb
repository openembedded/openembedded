require xorg-app-common.inc
DEPENDS += " virtual/libx11 libxmu xbitmaps libxt"
PE = "1"
