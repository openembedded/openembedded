require xorg-app-common.inc
PE = "1"

DEPENDS += " libxaw virtual/libx11 libxt libxmu"

