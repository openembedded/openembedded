require xorg-app-common.inc

#DESCRIPTION = "X Session Manager"

DEPENDS += " libxaw libxt"

