require xorg-app-common.inc
PE = "1"

DESCRIPTION = "X Session Manager"

DEPENDS += " libxaw libxt"

