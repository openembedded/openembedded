require xorg-app-common.inc
PE = "1"

DESCRIPTION = "bdftopcf is a font compiler for the X server and font server."

DEPENDS += " libxfont"

