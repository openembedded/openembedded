require xorg-app-common.inc
PE = "1"

DESCRIPTION = "a tool for manipulating ICE protocol authorization records"

DEPENDS += " virtual/libx11 libxt"

