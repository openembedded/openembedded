include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " virtual/x11 libxaw libxrender libxft libxkbfile libxt"

