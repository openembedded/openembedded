require xorg-app-common.inc
PE = "1"

DEPENDS += " libxmu libxext virtual/libx11"

