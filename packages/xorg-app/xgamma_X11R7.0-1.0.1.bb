include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " virtual/x11 libxxf86vm"

