include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxp libxprintutil virtual/x11"

