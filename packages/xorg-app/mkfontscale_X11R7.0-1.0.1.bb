include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " zlib libfontenc freetype libx11"

