include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libx11 libxfont libfs libfontenc"

