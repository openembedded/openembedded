require xorg-app-common.inc
DESCRIPTION = "scientific calculator for X"
DEPENDS += " libxaw libxt"
PE = "1"
