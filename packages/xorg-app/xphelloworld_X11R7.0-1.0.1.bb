include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libx11 libxprintapputil libxaw libxprintutil libxt libxp"

