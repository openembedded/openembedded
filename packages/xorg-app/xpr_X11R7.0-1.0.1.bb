include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxmu virtual/libx11"

