include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libx11"
FILES_${PN} += "  /usr/lib/X11/xinit"

