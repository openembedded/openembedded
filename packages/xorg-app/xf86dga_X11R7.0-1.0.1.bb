include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " virtual/libx11 libxxf86dga libxt libxaw libxmu"

