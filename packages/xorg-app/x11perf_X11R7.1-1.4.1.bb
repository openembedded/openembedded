include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libx11 libxmu libxrender libxft libxext"
