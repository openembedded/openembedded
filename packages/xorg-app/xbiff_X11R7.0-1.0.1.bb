include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxaw xbitmaps libxext"

