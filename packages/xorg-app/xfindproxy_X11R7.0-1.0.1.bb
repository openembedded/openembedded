require xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " virtual/libx11 libice libxt xproxymngproto"

