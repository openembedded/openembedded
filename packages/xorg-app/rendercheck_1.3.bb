require xorg-app-common.inc

DESCRIPTION = "a program to test Render extension implementations"
DEPENDS += "libxrender"
