require xorg-app-common.inc
PE = "1"

DEPENDS += " libxi virtual/libx11"

