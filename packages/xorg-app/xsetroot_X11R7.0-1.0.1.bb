include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxmu virtual/x11 xbitmaps"

