require xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " xproto libice"

