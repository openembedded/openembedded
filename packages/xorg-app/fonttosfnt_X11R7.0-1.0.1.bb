include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " xproto freetype libfontenc"

