require xorg-app-common.inc
PE = "1"

DESCRIPTION = "an X graphics demo using an animated polyhedron"

DEPENDS += " virtual/libx11 libxau libxdmcp"
