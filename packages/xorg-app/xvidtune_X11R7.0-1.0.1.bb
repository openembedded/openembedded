include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxaw libxxf86vm libxt"

