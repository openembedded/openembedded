require xorg-app-common.inc
PE = "1"

DEPENDS += " libxp virtual/libx11"

