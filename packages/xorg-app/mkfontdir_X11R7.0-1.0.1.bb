require xorg-app-common.inc

RDEPENDS += "mkfontscale"

