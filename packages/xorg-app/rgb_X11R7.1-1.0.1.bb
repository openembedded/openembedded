include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " xproto util-macros"


