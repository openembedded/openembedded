include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxt libxmu"

