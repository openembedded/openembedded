require xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxaw libxprintutil libxp libxrender libxft libxext libxt"

