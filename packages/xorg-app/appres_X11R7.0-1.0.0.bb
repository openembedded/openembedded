include xorg-app-common.inc

DESCRIPTION = "The appres program prints the resources seen by an application."

DEPENDS += " virtual/libx11 libxt"

