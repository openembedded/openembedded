include app-common.inc
DEPENDS = "libx11 libxkbfile"
