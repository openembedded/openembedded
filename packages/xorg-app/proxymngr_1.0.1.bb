require xorg-app-common.inc
PE = "1"

DEPENDS += " libice libxt virtual/libx11 xproxymngproto"

