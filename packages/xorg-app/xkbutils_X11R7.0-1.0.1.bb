include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxaw libxkbfile libx11"

