include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " zlib zlib virtual/x11 libfontenc"

