include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxkbfile libx11"

