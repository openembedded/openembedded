require xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxaw libxt"

