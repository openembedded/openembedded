require xorg-app-common.inc

DESCRIPTION = "X authority file utility"
DEPENDS += "libxau libxext libxmu"
FILE_PR = "r1"
PE = "1"
