include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libx11"

