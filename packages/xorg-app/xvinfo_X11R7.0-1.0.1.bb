include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxv virtual/x11"

