require xorg-app-common.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " libxkbfile virtual/libx11"

