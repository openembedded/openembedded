include xorg-app-common.inc

DESCRIPTION = "Server access control program for X"
MAINTAINER = "Rene Wagner <rw@handhelds.org>"
LICENSE = "MIT"

DEPENDS += " virtual/x11 libxmu libxau"

