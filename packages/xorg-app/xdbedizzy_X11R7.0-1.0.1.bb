require xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxp libxprintutil libxp libxau libxext"

