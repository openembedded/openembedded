include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxaw libxprintutil libxp libxt"

