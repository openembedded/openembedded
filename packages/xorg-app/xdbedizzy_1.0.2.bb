require xorg-app-common.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " libxp libxprintutil libxp libxau libxext"

