include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxaw virtual/x11 libxt libxext xtrans xproxymngproto libxau"

