include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " virtual/libx11 glproto mesa"

