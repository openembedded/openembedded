require xorg-app-common.inc
PE = "1"

DESCRIPTION = "X fontserver"

DEPENDS += " libfs libxfont xtrans"

