require xorg-app-common.inc

DESCRIPTION = "bdftopcf is a font compiler for the X server and font server."

DEPENDS += " libxfont"

