require xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxaw freetype fontconfig libxft libxt"

