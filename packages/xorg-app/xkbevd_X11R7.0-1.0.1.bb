include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxkbfile virtual/libx11"

