require xorg-app-common.inc

DESCRIPTION = "used for creating global (system-wide) Compose cache files"
