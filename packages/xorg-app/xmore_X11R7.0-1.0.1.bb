require xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxprintutil libxp libxt"

