include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxp libx11"

