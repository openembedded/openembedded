include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libice libxt virtual/libx11 xproxymngproto"

