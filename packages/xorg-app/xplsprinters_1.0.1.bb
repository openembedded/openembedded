require xorg-app-common.inc
PE = "1"

DEPENDS += " libxp libxprintutil virtual/libx11"

