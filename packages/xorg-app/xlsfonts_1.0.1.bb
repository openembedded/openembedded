require xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " virtual/libx11"
