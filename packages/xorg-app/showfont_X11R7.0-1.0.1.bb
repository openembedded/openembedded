include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libfs"

