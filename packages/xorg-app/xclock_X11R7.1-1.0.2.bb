include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libx11 libxaw libxrender libxft libxkbfile libxt"

