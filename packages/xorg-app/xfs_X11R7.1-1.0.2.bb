include xorg-app-common.inc

DESCRIPTION = "X fontserver"

DEPENDS += " libfs libxfont xtrans"

