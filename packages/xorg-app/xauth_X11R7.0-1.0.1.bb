include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libx11 libxau libxext libxmu"

