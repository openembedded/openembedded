require xorg-app-common.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " zlib zlib virtual/libx11 libfontenc"

