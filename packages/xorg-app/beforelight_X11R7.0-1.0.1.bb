include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libx11 libxscrnsaver libxt libxaw libxt"

