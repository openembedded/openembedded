include xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libx11 libxau libxt libxext libxmu"
