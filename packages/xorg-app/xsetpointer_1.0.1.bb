require xorg-app-common.inc

DESCRIPTION = "set an X Input device as the main pointer"
DEPENDS += " libxi virtual/libx11"
PE = "1"
