DESCRIPTION = "Python Linux Inotify Wrapper"
SECTION = "devel/python"
HOMEPAGE = "http://rudd-o.com/projects/python-inotify/"
LICENSE = "GPL"
PR = "ml0"

SRC_URI = "http://rudd-o.com/wp-content/uploads/projects/files/python-inotify/python-inotify-${PV}.tar.gz"

inherit distutils

