require python-efl.inc
DEPENDS += "epsilon python-evas"

PR = "r0"
