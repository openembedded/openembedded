require python-efl.inc
DEPENDS += "emotion python-evas"
RDEPENDS += "python-ecore"
PV = "0.2.1+svnr${SRCREV}"
PR = "r1"
