require python-pygobject_${PV}.bb

DEPENDS = "python-native"
