DESCRIPTION = "The constraint package is a constraint \
satisfaction problem solver written in 100% pure Python, using \
constraint propagation algorithms. So far, facilities are \
provided to work with finite domains only."
SECTION = "devel/python"
PRIORITY = "optional"
LICENSE = "GPL"
PR = "ml0"

SRC_URI = "http://labix.org/download/python-constraint/python-constraint-${PV}.tar.bz2"

inherit distutils

