DESCRIPTION = "Python Bindings to the Enlightenment Foundation Libraries"
LICENSE = "MIT"
SECTION = "devel/python"
RDEPENDS = "python-evas python-ecore python-emotion python-edje python-epsilon"
PR = "ml1"

ALLOW_EMPTY = "1"
