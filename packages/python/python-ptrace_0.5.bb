DESCRIPTION = "python-ptrace is a debugger using ptrace."
HOMEPAGE = "http://python-ptrace.hachoir.org/trac"
SECTION = "devel/python"
LICENSE = "GPLv2"
PR = "ml0"

SRC_URI = "http://pypi.python.org/packages/source/p/python-ptrace/python-ptrace-${PV}.tar.gz"

inherit distutils
