require python-efl.inc
DEPENDS += "epsilon python-ecore"
RDEPENDS += "python-ecore"
PV = "0.3.0+svnr${SRCREV}"
FILE_PR = "r0"
