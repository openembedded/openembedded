require python-efl.inc

DEPENDS += "edje python-evas"

