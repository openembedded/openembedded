DESCRIPTION = "Python IRC (Internet Relay Chat) Support Library"
SECTION = "devel/python"
HOMEPAGE = "http://python-irclib.sourceforge.net/"
PRIORITY = "optional"
LICENSE = "LGPL"
PR = "ml0"

SRC_URI = "${SOURCEFORGE_MIRROR}/python-irclib/python-irclib-${PV}.tar.gz"

inherit distutils

