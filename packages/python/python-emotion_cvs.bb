require python-efl.inc

DEPENDS += "emotion python-evas"

