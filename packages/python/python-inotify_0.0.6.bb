DESCRIPTION = "Python Linux Inotify Wrapper"
SECTION = "devel/python"
LICENSE = "GPL"

SRC_URI = "http://www.vanille.de/mirror/python-inotify-${PV}.tar.gz"

inherit distutils

