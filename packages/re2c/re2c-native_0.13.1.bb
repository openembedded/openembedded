require re2c.inc 

FILE_PR = "r0"

inherit native
