LICENSE = "GPL"
inherit gpe

DESCRIPTION = "GPE time tracker"
DEPENDS = "libgpewidget gtk+ sqlite"
SECTION = "gpe"
RDEPENDS = "gpe-icons"
