require uim_${PV}.bb
DEPENDS = "anthy-native"
inherit native

SRC_URI = "http://uim.freedesktop.org/releases/uim-${PV}.tar.gz"
