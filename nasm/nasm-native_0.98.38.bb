SECTION = "unknown"
include nasm_${PV}.bb
S = "${WORKDIR}/nasm-${PV}"
inherit native
