require scim.inc
