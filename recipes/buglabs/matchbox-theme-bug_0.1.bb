DESCRIPTION = "Matchbox window manager red BUG theme"

THEME_NAME="Bug"
PR = "r2"

include matchbox-theme-bug.inc
