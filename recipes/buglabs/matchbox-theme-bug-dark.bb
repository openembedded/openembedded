DESCRIPTION = "Matchbox window manager dark BUG theme"

THEME_NAME="Bug-Dark"
PR="r18"

include matchbox-theme-bug.inc
