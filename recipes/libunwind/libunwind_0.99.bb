require libunwind.inc
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "3e9ca08118e22165a7f07d01d61a2d0d"
SRC_URI[archive.sha256sum] = "56083aae17eab3ccb7a36b95f0430f5a5f258755bf193bb5ca4fd4b918356164"
