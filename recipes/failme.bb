
do_configure() {
idontexist
}

