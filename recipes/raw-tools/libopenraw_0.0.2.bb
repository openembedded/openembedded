require libopenraw.inc

SRC_URI = "http://libopenraw.freedesktop.org/download/libopenraw-${PV}.tar.gz"

