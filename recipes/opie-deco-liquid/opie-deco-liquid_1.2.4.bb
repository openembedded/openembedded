require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_noncore_decorations_liquid.tar.bz2;name=split_noncore_decorations_liquid"
SRC_URI[split_noncore_decorations_liquid.md5sum] = "2a3696459fda7e44bb18acdefabb2fcf"
SRC_URI[split_noncore_decorations_liquid.sha256sum] = "6ff6fe62c6230017fe69e4a351b8ca434dfafdc3f07b16d60d866fcec10697f4"
