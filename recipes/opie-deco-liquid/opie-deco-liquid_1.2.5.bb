require ${PN}.inc

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_noncore_decorations_liquid.tar.bz2;name=split_noncore_decorations_liquid"
SRC_URI[split_noncore_decorations_liquid.md5sum] = "7cf38be689a0b3c906fb1174adabe4f7"
SRC_URI[split_noncore_decorations_liquid.sha256sum] = "aede43b516e546e580177693a15af7e5949482688d9e8e941c8a0382cb401987"
