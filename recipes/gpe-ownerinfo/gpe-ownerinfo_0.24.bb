require gpe-ownerinfo.inc

PR = "r2"

SRC_URI += "file://fixloop.patch;patch=1;pnum=0"

SRC_URI[md5sum] = "c199248a2100398445542af9cab43338"
SRC_URI[sha256sum] = "e997f5fda35c635533d37827c8a76361e124426ac5a130a18deebbd77b7502a8"
