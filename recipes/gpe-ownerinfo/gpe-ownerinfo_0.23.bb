require gpe-ownerinfo.inc

PR = "r1"

SRC_URI[md5sum] = "172ce9f0a83b11eb1bb36a5b87e74e00"
SRC_URI[sha256sum] = "bfd89166940eba6139173d922af4834e2dd36e75c29c0f5ac6702f5188d7ae7b"
