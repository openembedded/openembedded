require gpe-ownerinfo.inc

PR = "r0"

SRC_URI[md5sum] = "db85239008c08072c7fca7de528d2f84"
SRC_URI[sha256sum] = "9616a0cf943e72974bc27fd4c90d76871ba9642f9f45e2119a3b8180930ce534"
