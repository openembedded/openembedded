require gpe-ownerinfo.inc

PR = "r0"

SRC_URI[md5sum] = "30e0da89ab7610e53d5d15f7489d7982"
SRC_URI[sha256sum] = "9011bf84c445b45aff1aedff23370df2877585d60d5c5e9fe2119095e5440b7f"
