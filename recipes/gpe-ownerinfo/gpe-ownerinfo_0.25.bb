require gpe-ownerinfo.inc

PR = "r0"

SRC_URI[md5sum] = "bdfe3aef56a0fa27e10af29dedd96083"
SRC_URI[sha256sum] = "d06d917ce07cb3fedcd98aa558bc9f16473c8eeb9817ab8e68baeabd2a9152bd"
