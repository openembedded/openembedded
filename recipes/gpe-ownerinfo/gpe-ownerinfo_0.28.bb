require gpe-ownerinfo.inc

PR = "r3"

SRC_URI += "file://compile.patch"

SRC_URI[md5sum] = "25b02a6d7fbbb2966e2481930bd55591"
SRC_URI[sha256sum] = "3072876709e8fb58eda893ec0acb50b3eb6b8a7c808f4fbd74657c139933971a"
