require sofia-sip.inc

PR = "r1"

SRC_URI[archive.md5sum] = "c6d7c4c6318fe1ac661862062aad241a"
SRC_URI[archive.sha256sum] = "86a9522f4ccb17c3b86916784e1de1dce5fe72df6dab06db91f73c2cd3ab96f4"
