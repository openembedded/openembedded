require sofia-sip.inc

PR = "r2"

SRC_URI[archive.md5sum] = "09d027ee9817cc1a1b8c0e96271bade4"
SRC_URI[archive.sha256sum] = "328531d0f522a207a9721223c92b823643af5c82e5958fc5e9c945ea36ddafd6"
