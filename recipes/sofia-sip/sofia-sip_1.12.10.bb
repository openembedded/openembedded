require sofia-sip.inc

SRC_URI[archive.md5sum] = "9e07fde3ad2009e44d1100ca3950d02b"
SRC_URI[archive.sha256sum] = "e6648382f24c73997f83e153cfef7f42125bf0dd3af73b98ca623e10ec321663"
