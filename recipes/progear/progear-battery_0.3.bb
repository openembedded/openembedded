require progear.inc

DESCRIPTION += "Battery support"

SRC_URI += "file://kernel-update.patch;patch=1"
