require progear.inc

DESCRIPTION += "AC detection support"
