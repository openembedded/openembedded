require vala-dbus-binding-tool.inc
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "8f92d071d34c218dc163760aaabaed41"
SRC_URI[archive.sha256sum] = "120db21e8902d12d571cabc4973e343b4308a48873ffb112f84a9f8b75571ad7"
