require vala-dbus-binding-tool.inc
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "8eb2cb84970d7bc3c4a1ffd9de9d6e02"
SRC_URI[archive.sha256sum] = "8da916ffa72281d890c391f07ab03899f3db07bf0113a2be47121c3155efbe7f"
