require vala-dbus-binding-tool.inc
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "9a758057798991de66a44608f8b80895"
SRC_URI[archive.sha256sum] = "a89823ee30054b5837d670859bb07f6ec414279f4603c420fe67399380ddffdb"
