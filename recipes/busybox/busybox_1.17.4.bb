require busybox_1.1x.inc
PR = "${INC_PR}.1"

SRC_URI[md5sum] = "b3254232e9919007ca803d3a4fe81f3c"
SRC_URI[sha256sum] = "0c6b80f007e665228d1b271354b7e80450dcaa67c9162a30eebf936c7cdfcbdc"
