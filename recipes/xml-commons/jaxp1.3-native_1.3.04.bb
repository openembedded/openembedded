require jaxp1.3_${PV}.bb

inherit java-native

