require xml-commons-resolver1.1_${PV}.bb

inherit java-native

DEPENDS = "fastjar-native jaxp1.3-native"

