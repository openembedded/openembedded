require u-boot-omap3.inc

DEFAULT_PREFERENCE_ti816x = "1"
BRANCH = "ti816x-master"
COMPATIBLE_MACHINE = "ti816x"

# Use literal tags in SRCREV, when available, instead of commit IDs
SRCREV = "v2010.03_TI816XPSP_04.00.00.05"

UVER = "2010.03"
PSPREL = "04.00.00.05"

PR = "r2"
