require ${PN}.inc

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_core_settings_launcher.tar.bz2 \
           http://sources.openembedded.org/opie-1.2.5-split_apps.tar.bz2 \
           http://sources.openembedded.org/opie-1.2.5-split_pics.tar.bz2"
