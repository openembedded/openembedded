require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_noncore_styles_phase.tar.bz2;name=split_noncore_styles_phase"
SRC_URI[split_noncore_styles_phase.md5sum] = "892ffa69e8e4860aa885d5daf2b84cf1"
SRC_URI[split_noncore_styles_phase.sha256sum] = "658a41e9c703e9191f8c2df10bf49995953366419b03d20028526412691b0732"
