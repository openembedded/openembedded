require ${PN}.inc

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_noncore_styles_phase.tar.bz2;name=split_noncore_styles_phase"
SRC_URI[split_noncore_styles_phase.md5sum] = "1277a508c641c9c031c328fe33c7cd5d"
SRC_URI[split_noncore_styles_phase.sha256sum] = "f9bfab751be7bf779f1564756b46db8119caae81db5e1112e605b0c7a90a98cc"
