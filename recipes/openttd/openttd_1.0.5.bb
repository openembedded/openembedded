require openttd.inc

PR = "r0"

SRC_URI[md5sum] = "20e54ce55dcbee834f5aaf528c999c7e"
SRC_URI[sha256sum] = "24564626c0c8169e9db9aa3e5ddc0c581a2ea361b1e0281eb40f11f1ca308af6"
