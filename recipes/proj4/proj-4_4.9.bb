require proj-4.inc

DEPENDS += "proj-4-native"


SRC_URI[md5sum] = "3cc5c2407c213aadfd154c8df80efd6c"
SRC_URI[sha256sum] = "672b753f911bfb7cbf996ece57f46dd91d3bac9aa852178e3a56b5e111672aa9"
