require proj-4.inc

inherit native
