# xffm OE build file
# Copyright (C) 2004, Advanced Micro Devices, Inc.  All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require ${PN}.inc

SRC_URI = "http://www.us.xfce.org/archive/xfce/${XFCE_VERSION}/src/${PN}-${PV}.tar.gz"

SRC_URI[md5sum] = "5eb5ede5b2bfac564c26d96ee06a3241"
SRC_URI[sha256sum] = "0cde8831dc56669a046f6284b0a8dabd583942837e41832e7ed57e57020c4446"