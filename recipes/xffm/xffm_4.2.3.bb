# xffm OE build file
# Copyright (C) 2004, Advanced Micro Devices, Inc.  All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require ${PN}.inc

SRC_URI = "http://www.us.xfce.org/archive/xfce/${XFCE_VERSION}/src/${PN}-${PV}.tar.gz"

SRC_URI[md5sum] = "5d2a990bb725b6720db93f34dd91a731"
SRC_URI[sha256sum] = "791a05a2fd695508ff6b3fd3e0e2be66de28a3d0bf86ee22e14126992d7aef21"