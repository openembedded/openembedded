require directfb.inc

RV = "1.1-0"
PR = "r6"

LEAD_SONAME = "libdirect-1.1.so"

SRC_URI[md5sum] = "da30fa2748c7501913c8832a83e654ab"
SRC_URI[sha256sum] = "0ee87256a278079955d78e4f235c15a174afbb507b5434f1966cd3e5f5a3f23a"
