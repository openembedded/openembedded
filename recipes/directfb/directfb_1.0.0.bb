require directfb.inc


SRC_URI += "file://fix-includes.patch;patch=1" 

RV = "1.0-0"
PR = "r6"

SRC_URI[md5sum] = "ad746c49dc89ba6f99df71b17bbb1dc8"
SRC_URI[sha256sum] = "125941749103c08a5263f2ace01aac1533420d2ff6741d2bdde79689e5d02a05"
