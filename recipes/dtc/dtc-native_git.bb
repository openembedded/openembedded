require dtc-native.inc

SRC_URI = "git://www.jdl.com/software/dtc.git;protocol=git"

S = "${WORKDIR}/git"

