require dtc.inc

PR = "r1"

SRC_URI = "http://www.jdl.com/pub/software/dtc-${PV}.tgz"

S = "${WORKDIR}/dtc"

