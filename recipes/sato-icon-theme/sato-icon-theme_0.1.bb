require sato-icon-theme.inc

SRC_URI = "http://pokylinux.org/releases/sato/sato-icon-theme-${PV}.tar.gz"

SRC_URI[md5sum] = "c9a9117454dafa41fe28cc3f829a87e7"
SRC_URI[sha256sum] = "23b753434625e2b2206bf77045cf16f72086bb84a2339b5058481270643200fe"
