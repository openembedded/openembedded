require wpa-supplicant-0.6.inc

PR = "${INC_PR}.1"
