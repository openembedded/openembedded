require wpa-supplicant-0.6.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "b61f6e94b63f92173f4286b5e6a84140"
SRC_URI[sha256sum] = "7c698fe145785b63e584da02b21a7e9a32b0929e35fc0bc67ad99af6d5217f64"
