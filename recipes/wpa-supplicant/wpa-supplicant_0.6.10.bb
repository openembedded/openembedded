require wpa-supplicant-0.6.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "8985b1030d753e5f74f8acfc34e591bb"
SRC_URI[sha256sum] = "ac27c69c26e3f4e06fba13e0dc8e1c7ed7b0012a95263bcfcf0f39be8059f2fd"
