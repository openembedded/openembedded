require wpa-supplicant-0.6.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "635c7af7cecb39954997146b5c734b1c"
SRC_URI[sha256sum] = "24ce7873cbf2b23c00f931dd7f20326bea5463dd2a50a865b3d9bffd3f5780b7"
