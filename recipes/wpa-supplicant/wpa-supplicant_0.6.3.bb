require wpa-supplicant-0.6.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "b51b2975f21006f85f7297f3fb1acde1"
SRC_URI[sha256sum] = "f70b18243e049bbda66254388b6e94d404e747d913b8496d6e93a9c56bbf4af2"
