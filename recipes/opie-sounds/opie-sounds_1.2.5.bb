require ${PN}.inc

PR = "r0"

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_sounds.tar.bz2;name=split_sounds"
SRC_URI[split_sounds.md5sum] = "b0f2bee8c158f54162e5e74d4d9594df"
SRC_URI[split_sounds.sha256sum] = "55441675b28209cb2e34ffc0875c6d47aee27bd65dbdb40a223e5fa05c5a7c06"
