TAG = "v${PV}"
require libsocketcan.inc

PR = "${INC_PR}.0"
