TAG = "canutils-${PV}"
require canutils.inc

PR = "${INC_PR}.0"
