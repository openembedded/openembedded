require sysklogd.inc
PR = "r1"

SRC_URI += "file://no-strip-install.patch;patch=1"
