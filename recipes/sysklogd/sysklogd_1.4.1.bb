require sysklogd.inc
