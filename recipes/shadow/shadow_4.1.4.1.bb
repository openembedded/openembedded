require shadow.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "62f7dae4cb54fa84e478c4602d58cbe8"
SRC_URI[sha256sum] = "f3dc204a67c587d1e0a5ad2de24ee584adb3f30c604444e554de29e379fec844"
