require ${PN}.inc

PR = "r0"

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_inputmethods_unikeyboard.tar.bz2;name=split_inputmethods_unikeyboard"
SRC_URI[split_inputmethods_unikeyboard.md5sum] = "ec4037ab5076d196b0a65cb232a9a7aa"
SRC_URI[split_inputmethods_unikeyboard.sha256sum] = "3262bf997a9e0f99a07c9b5fdaa387bdcb07506b1a629977c6eae2f215e6758e"
