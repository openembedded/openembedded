require batctl.inc
PR = "${INC_PR}.0"


SRC_URI[md5sum] = "8eb197896049bb04a6beef56015a16b6"
SRC_URI[sha256sum] = "94922fd167d2bca5193cc7465bfc212c2c3595da70e653506493dfc65e4410fb"
