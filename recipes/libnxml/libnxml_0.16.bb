require libnxml.inc

PR = "${INC_PR}.0"


SRC_URI[md5sum] = "85b6a42a9e17a23c01b2f2ed0ece0563"
SRC_URI[sha256sum] = "6154872089834b0ffd34e92612d07e2d1ccec572698bd861da752eeeaab7ca78"
