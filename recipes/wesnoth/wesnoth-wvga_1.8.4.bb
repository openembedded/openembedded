require wesnoth.inc

RCONFLICTS_${PN} = "wesnoth"

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "2dce83f835ecce1d505ea60e46b7356f"
SRC_URI[sha256sum] = "af29ddf40f83ee016972d6edb8761d7323f8ed5d6bf15005659bff4fd7190eb9"
