require squashfs-tools.inc
PR = "${INC_PR}.0"

SRC_URI += " file://Makefile.patch"
