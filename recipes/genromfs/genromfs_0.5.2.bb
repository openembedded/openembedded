require genromfs.inc

PR = "${INC_PR}.0"

SRC_URI = "${SOURCEFORGE_MIRROR}/romfs/genromfs-0.5.2.tar.gz"
SRC_URI[md5sum] = "2a91463c56f9e042edc330c063a0cf5a"
SRC_URI[sha256sum] = "30f37fc734572c1dbaa2504585bc23ba6b8fd7df767ae7155995b2ca0ebed960"
