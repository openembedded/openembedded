require gmailfs.inc

SRC_URI[md5sum] = "828417eb7355b61b0f474eabc826317f"
SRC_URI[sha256sum] = "69d8553b351c461a8e36ed633aa2da14fdb79423b9ce0e6d3174e5ace09fadd8"
