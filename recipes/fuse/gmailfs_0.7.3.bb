require gmailfs.inc

SRC_URI[md5sum] = "306a58990ae299083bc9d704899ed1c5"
SRC_URI[sha256sum] = "3539e060e3d02f4732c79c9a02e93898c562e2f2d77828ef4825ac6b1447a444"
