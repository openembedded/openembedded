require aaina.inc

SRCREV = "3597"
PV = "0.3.0+svnr${SRCREV}"

SRC_URI = "svn://svn.o-hand.com/repos/clutter/trunk/toys;module=aaina;proto=http"

S = "${WORKDIR}/aaina"
