require clutter-gtk.inc

PR = "${INC_PR}.0"

SRC_URI = "http://source.clutter-project.org/sources/clutter-gtk/0.10/clutter-gtk-${PV}.tar.bz2 \
          "

SRC_URI[md5sum] = "22b4ebddc795e40d83622d7d23669eff"
SRC_URI[sha256sum] = "7867f951568871d9f68cbe8a3644fd53d2138f725b7ba61ffc0053eb64e80814"

