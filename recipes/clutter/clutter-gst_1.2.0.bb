require clutter-gst.inc

PR = "${INC_PR}.0"

SRC_URI = "http://source.clutter-project.org/sources/clutter-gst/1.2/clutter-gst-${PV}.tar.bz2 \
          "

SRC_URI[md5sum] = "1048815f0c9152edbfdc59a94d0e3b87"
SRC_URI[sha256sum] = "ed3357c10fe82727091616296abd53c752e15c816a4030474f1919c0d347e5d3"
