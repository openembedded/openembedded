require clutter.inc

PV = "0.3.1+svn${SRCDATE}"
PR = "${INC_PR}.0"

SRC_URI = "svn://svn.o-hand.com/repos/clutter/trunk;module=clutter;proto=http"

S = "${WORKDIR}/clutter"


