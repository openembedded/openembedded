require clutter-box2d.inc

PV = "0.0+svnr${SRCPV}"
PR = "r4"
SRCREV = "3197"

SRC_URI = "svn://svn.o-hand.com/repos/clutter/trunk;module=${PN};proto=http"

S = "${WORKDIR}/${PN}"


