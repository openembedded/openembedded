require clutter-gtk.inc

PR = "${INC_PR}.1"

SRC_URI = "http://source.clutter-project.org/sources/clutter-gtk/0.10/clutter-gtk-${PV}.tar.bz2 \
          "

SRC_URI[md5sum] = "e7407392b14d6cddd9d4f86feaa9bd3f"
SRC_URI[sha256sum] = "c65ec1e6b2932ed23b3db145357a96ae5ec7cb0666139468eba781d6c56a5371"

