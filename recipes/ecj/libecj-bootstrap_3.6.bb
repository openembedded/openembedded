require libecj-bootstrap.inc

PR = "r0"

SRC_URI = " \
	   http://mirrors.ibiblio.org/pub/mirrors/eclipse/eclipse/downloads/drops/R-3.6-201006080911/ecjsrc-${PV}.zip \
          "

SRC_URI[md5sum] = "25975087b48145eef4ff5f161e792f3e"
SRC_URI[sha256sum] = "bc2d624c5ca135d593c71a677674509f5801998ffe98c386749d15a46ee69242"
