require libecj-bootstrap.inc

SRC_URI = "\
	http://mirrors.ibiblio.org/pub/mirrors/eclipse/eclipse/downloads/drops/R-3.3-200706251500/ecjsrc.zip \
  "

