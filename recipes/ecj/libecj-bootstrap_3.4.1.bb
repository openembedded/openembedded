require libecj-bootstrap.inc

PR = "r1"

SRC_URI = "\
	http://mirrors.ibiblio.org/pub/mirrors/eclipse/eclipse/downloads/drops/R-3.4.1-200809111700/ecjsrc-3.4.1.zip \
          "

