require libecj-bootstrap.inc

SRC_URI = "\
	http://mirrors.ibiblio.org/pub/mirrors/eclipse/eclipse/downloads/drops/R-3.3.2-200802211800/ecjsrc.zip \
  "

