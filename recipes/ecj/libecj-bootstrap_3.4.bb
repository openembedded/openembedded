require libecj-bootstrap.inc

PR = "r1"

SRC_URI = "\
	http://archive.eclipse.org/eclipse/downloads/drops/R-3.4-200806172000/ecjsrc-3.4.zip \
  "

