require util-macros.inc
PR = "${INC_PR}.0"
SRC_URI[archive.md5sum] = "a0585d3004bc5ddfc64e4dcae0fdd3f6"
SRC_URI[archive.sha256sum] = "964703055e87b6c6a7ebb91580d287da629ac7de90f43c8abff3f0cf54425c0d"
