require xorg-util-common.inc

DESCRIPTION = "X autotools macros"
PE = "1"

ALLOW_EMPTY = "1"

SRC_URI[archive.md5sum] = "eb991c709781f811fbfcdbd43f9edd16"
SRC_URI[archive.sha256sum] = "12c7a8819f2df62ff7fca20152438d6b4e93ac581d7de211e31149739aa37ce9"
