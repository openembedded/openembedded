require xorg-util-common.inc

DESCRIPTION = "create dependencies in makefiles"
DEPENDS = "xproto util-macros"
PR = "r3"
PE = "1"
