require xorg-util-common.inc

DESCRIPTION = "C preprocessor interface to the make utility"
RDEPENDS = "perl xproto"

PR = "r2"
PE = "1"
SRC_URI[archive.md5sum] = "579377af36a146913b3429cad1f7e8ab"
SRC_URI[archive.sha256sum] = "5d149c3cc9a0d7eca2a4bb44e5597f50f6d7ec75b61d7ca2ded842294214012d"
