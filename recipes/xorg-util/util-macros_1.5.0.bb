require util-macros.inc
PR = "${INC_PR}.0"
SRC_URI[archive.md5sum] = "ffef78135535c60c2b68d0a2a4ecae9b"
SRC_URI[archive.sha256sum] = "d47116ce5df198859a6082af7a72505575d1685b8c82bb4ef6fbedfa3316617e"
