require xorg-util-common.inc

DESCRIPTION = "C preprocessor interface to the make utility"
RDEPENDS = "perl xproto"

PR = "r2"
PE = "1"
