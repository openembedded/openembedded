require xorg-util-common.inc

DESCRIPTION = "create a shadow directory of symbolic links to another directory tree"
PR = "r2"
PE = "1"
SRC_URI[archive.md5sum] = "555a53da329931ac795931f5f69ccb5c"
SRC_URI[archive.sha256sum] = "ec6e73434bdcb229edc58e6d575185762c533ea366e7f949603b1c8f442887e3"
