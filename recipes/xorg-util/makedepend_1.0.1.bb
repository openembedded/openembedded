require makedepend.inc
PR = "${INC_PR}.0"
SRC_URI[archive.md5sum] = "90f5f3b987497a481b94d49372f17dce"
SRC_URI[archive.sha256sum] = "0a4a0d4e2613b0cd4321e55fd4741788b728736fc8a517996e2015fa49862e61"
