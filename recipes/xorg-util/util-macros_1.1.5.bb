require util-macros.inc
SRC_URI += "file://unbreak_cross_compile.patch;patch=1"
PR = "${INC_PR}.0"
