require xorg-util-common.inc

DESCRIPTION = "create a shadow directory of symbolic links to another directory tree"
PR = "r2"
PE = "1"
