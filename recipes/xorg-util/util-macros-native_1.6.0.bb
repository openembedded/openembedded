require util-macros_${PV}.bb

inherit native

XORG_PN = "util-macros"

S = "${WORKDIR}/util-macros-${PV}"
