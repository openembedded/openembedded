require makedepend.inc
PR = "${INC_PR}.0"
SRC_URI[archive.md5sum] = "ec37ca8b810a40cdfb16a736b3360f6c"
SRC_URI[archive.sha256sum] = "2d3466acc29b382a4368b30371f17a4083933281b97f8ef67fc8b785a60d52dc"
