require util-macros.inc
PR = "${INC_PR}.0"
SRC_URI[archive.md5sum] = "775895851365e0fc194394c5d1ea6df8"
SRC_URI[archive.sha256sum] = "ed552efc8c76334d404fd60bfc185eff4b020326ea2ae2212f25978927836ec9"
