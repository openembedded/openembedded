require util-macros.inc
PR = "${INC_PR}.0"
SRC_URI[archive.md5sum] = "31e9ddcbc1d8bc8c09ab180443974dd1"
SRC_URI[archive.sha256sum] = "7bff944fb120192e7fe1706e9c0b7e41666e7983ce3e2bdef0b7734392d9e695"
