require xorg-util-common.inc

DESCRIPTION = "C preprocessor interface to the make utility"
RDEPENDS_${PN} = "perl xproto"

PR = "r0"
PE = "1"
SRC_URI[archive.md5sum] = "0fd1e53d94142ddee5340f87de0b9561"
SRC_URI[archive.sha256sum] = "68038fa67929c5553044ad7417e1a64cabe954f04213b305dd36a04a61317d31"
