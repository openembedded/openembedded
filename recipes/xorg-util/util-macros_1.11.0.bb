require util-macros.inc
PR = "${INC_PR}.0"
SRC_URI[archive.md5sum] = "8580021f3a9e242ab09d23d62e475d53"
SRC_URI[archive.sha256sum] = "212c3d14474d7cffdbc22437d4896211a5dce6b99b02b96229c9be7d963c90cf"
