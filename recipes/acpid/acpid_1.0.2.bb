require acpid.inc
PR = "${INC_PR}.0"


SRC_URI[md5sum] = "15884aaf0b82717954f9366b5c00808b"
SRC_URI[sha256sum] = "7347042a5328b22965256d98462e8dd8f1cad37de992b135912f32c70163ae71"
