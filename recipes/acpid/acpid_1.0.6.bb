require acpid.inc
PR = "${INC_PR}.0"
SRC_URI[md5sum] = "5c9b705700df51d232be223b6ab6414d"
SRC_URI[sha256sum] = "aa3c42224ec702b6cdb69ca6501284cb6dacb87473a076d7337ee9635c96f160"
