require acpid.inc
SRC_URI += "file://gcc40.patch;patch=1"
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "3aff94e92186e99ed5fd6dcee2db7c74"
SRC_URI[sha256sum] = "032a95967f8dd8a227ee1771de4a2646becc4d0f1123568faeca931006ec8f5f"
