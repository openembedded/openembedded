require acpid.inc
SRC_URI += "file://gcc40.patch;patch=1"
PR = "${INC_PR}.0"
SRC_URI[md5sum] = "8513c19d0f14ff396ea73caaea7f2ef8"
SRC_URI[sha256sum] = "b36d6e83ecee4748cc3b8fa3cdbc8c59e620428ce77e22e241faa19c2e0e7dad"
