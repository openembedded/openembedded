require netkit-rpc_${PV}.bb
inherit native
