require tzdata.inc

SRC_URI = "http://ftp.uni-erlangen.de/pub/Linux/MIRROR.gentoo/distfiles/tzdata${PV}.tar.gz;name=tar \
"

SRC_URI[tar.md5sum] = "d0e8f560977470b0fc65b79b585cf5e4"
SRC_URI[tar.sha256sum] = "a069dbea2989613466f9f4adb6de381efb46aeb9ff89e03fabb23dcae2c4cd90"
