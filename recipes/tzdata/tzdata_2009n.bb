require tzdata.inc
SRC_URI = "ftp://elsie.nci.nih.gov/pub/tzdata${PV}.tar.gz"
PR = "${INC_PR}.0"
