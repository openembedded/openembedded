require tzdata.inc
SRC_URI = "http://bent.latency.net/bent/darcs/zoneinfo-${PV}/src/tzdata${PV}.tar.gz"
PR = "${INC_PR}.0"
