require m4.inc

PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "96ec473c2a6f203976c028e896a01b28"
SRC_URI[archive.sha256sum] = "0b7c686525b3f4236670f9329387d2a59e807b6a83d2b5cb9bbeb7d6ab9f8aad"
