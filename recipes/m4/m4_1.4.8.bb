require m4.inc

LICENSE = "GPL"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "6bbf917e5d8fab20b38d43868c3944d3"
SRC_URI[archive.sha256sum] = "d0e6734743f9eca530ea90c289c0f1770bdf37f846561557f0b0db7f87b7d7cc"
