require m4.inc

LICENSE = "GPL"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "eb93bfbcb12cf00165583302bb31a822"
SRC_URI[archive.sha256sum] = "5a06ae07a7c7b6e9895be14015468947ef3f95182e60400e840efb25feea4b8f"
