require m4.inc

PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "b3587c993523dd320c318ec456876839"
SRC_URI[archive.sha256sum] = "855217de304616931844f54bd00a1e03e92452f85de6caeec47b0e8244881ba3"
