require chicken_${PV}.bb

DEPENDS = "gcc-native"
RDEPENDS = "gcc-native"

inherit native

