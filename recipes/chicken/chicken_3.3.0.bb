require chicken.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "835401781fb606741ba3606fa3e89b78"
SRC_URI[sha256sum] = "5ce2519bac9956de5700a5777b2bbc2cd89202ef2d2252a40a0d1e8c9854bec6"
