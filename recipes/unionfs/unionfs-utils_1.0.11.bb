require unionfs-utils.inc
require unionfs.inc

SRC_URI[md5sum] = "494651fe0cf724c093b4be80e35e857f"
SRC_URI[sha256sum] = "f1df81423a65590ffd20df43f5cd0be14cf6746437eb40c2c924f5f58a6e18a7"
