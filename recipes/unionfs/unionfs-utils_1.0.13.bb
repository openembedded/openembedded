require unionfs-utils.inc


SRC_URI[md5sum] = "1dca48ff260dacf890b8040a3cea55b3"
SRC_URI[sha256sum] = "61b03ce855734b1a1b4b180856095876d562c22e359ba847a2544c488c7254b4"
