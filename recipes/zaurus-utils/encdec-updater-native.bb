require encdec-updater.bb
inherit native
