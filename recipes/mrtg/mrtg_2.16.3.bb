require mrtg.inc
SRC_URI[mrtg-2.16.3.md5sum] = "dfdda80c1d575081458cede58f979d81"
SRC_URI[mrtg-2.16.3.sha256sum] = "d5d04b8ab104200d370676813e924470d73cfe12b84380f4e17bc6a44cd498ed"