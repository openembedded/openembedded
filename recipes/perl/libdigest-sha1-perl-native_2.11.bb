SECTION = "libs"

inherit native

require libdigest-sha1-perl_${PV}.bb
