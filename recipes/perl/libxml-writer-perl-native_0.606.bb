SECTION = "libs"

require libxml-writer-perl_${PV}.bb

inherit native

