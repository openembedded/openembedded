SECTION = "libs"

inherit native

require libhtml-tagset-perl_${PV}.bb
