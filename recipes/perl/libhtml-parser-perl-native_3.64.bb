SECTION = "libs"

require libhtml-parser-perl_${PV}.bb

inherit native

