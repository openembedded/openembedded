SECTION = "libs"

inherit native

require libphp-serialization-perl_${PV}.bb
