SECTION = "libs"

inherit native

require libyaml-perl_${PV}.bb
