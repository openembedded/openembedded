SECTION = "libs"

require libio-stringy-perl_${PV}.bb

inherit native

