SECTION = "libs"

inherit native

require liblog-dispatch-perl_${PV}.bb
