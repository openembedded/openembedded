SECTION = "libs"

inherit native

require libalgorithm-diff-perl_${PV}.bb
