SECTION = "libs"

inherit native

require libdatetime-format-strptime-perl_${PV}.bb
