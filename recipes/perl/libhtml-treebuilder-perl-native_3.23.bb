SECTION = "libs"

require libhtml-treebuilder-perl_${PV}.bb

inherit native

