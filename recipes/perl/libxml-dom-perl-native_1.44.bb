SECTION = "libs"

require libxml-dom-perl_${PV}.bb

inherit native

