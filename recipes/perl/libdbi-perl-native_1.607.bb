SECTION = "libs"

inherit native

require libdbi-perl_${PV}.bb
