SECTION = "libs"

inherit native

require libtext-diff-perl_${PV}.bb
