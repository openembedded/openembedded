SECTION = "libs"

inherit native

require libsys-mmap-perl_${PV}.bb
