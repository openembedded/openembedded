SECTION = "libs"

inherit native

require libemail-date-format-perl_${PV}.bb
