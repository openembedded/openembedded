SECTION = "libs"

inherit native

require libextutils-cbuilder-perl_${PV}.bb
