SECTION = "libs"

inherit native

require libintl-perl_${PV}.bb
