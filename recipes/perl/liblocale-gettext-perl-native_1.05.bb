SECTION = "libs"

inherit native

require liblocale-gettext-perl_${PV}.bb
