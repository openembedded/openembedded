SECTION = "libs"

inherit native

require libextutils-pkgconfig-perl_${PV}.bb
