SECTION = "libs"

inherit native

require libextutils-depends-perl_${PV}.bb
