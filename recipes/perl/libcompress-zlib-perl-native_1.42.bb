SECTION = "libs"

inherit native

require libcompress-zlib-perl_${PV}.bb
