SECTION = "libs"

inherit native

require libextutils-makemaker-perl_${PV}.bb
