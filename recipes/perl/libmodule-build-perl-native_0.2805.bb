SECTION = "libs"

inherit native

require libmodule-build-perl_${PV}.bb

SRC_URI[md5sum] = "598bb59b86c2c4842eeffb03392fab5b"
SRC_URI[sha256sum] = "8fd609d1e6b460b5c95ad5612cb823aa863d51360ed55caea987909a9bab50f5"
