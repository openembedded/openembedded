SECTION = "libs"

inherit native

require libxml-regexp-perl_${PV}.bb
