SECTION = "libs"

inherit native

require libio-zlib-perl_${PV}.bb
