SECTION = "libs"

inherit native

require libsoap-lite-perl_${PV}.bb
