SECTION = "libs"

require libtermreadkey-perl_${PV}.bb

inherit native

