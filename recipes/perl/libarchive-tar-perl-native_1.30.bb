SECTION = "libs"

inherit native

require libarchive-tar-perl_${PV}.bb
