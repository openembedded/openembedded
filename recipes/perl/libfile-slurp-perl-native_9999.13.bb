SECTION = "libs"

require libfile-slurp-perl_${PV}.bb

inherit native

