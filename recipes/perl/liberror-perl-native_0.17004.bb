SECTION = "libs"

inherit native

require liberror-perl_${PV}.bb
