SECTION = "libs"

inherit native

require libdata-optlist-perl_${PV}.bb
