SECTION = "libs"

require libwww-mechanize-perl_${PV}.bb

inherit native

