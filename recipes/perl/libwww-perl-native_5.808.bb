SECTION = "libs"

inherit native

require libwww-perl_${PV}.bb
