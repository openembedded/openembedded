SECTION = "libs"

inherit native

require libdevice-serialport-perl_${PV}.bb
