PR = "r0"

require make.inc

SRC_URI[md5sum] = "354853e0b2da90c527e35aabb8d6f1e6"
SRC_URI[sha256sum] = "f3e69023771e23908f5d5592954d8271d3d6af09693cecfd29cee6fde8550dc8"
