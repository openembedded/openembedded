PR = "r0"

require make.inc

SRC_URI[md5sum] = "0bbd1df101bc0294d440471e50feca71"
SRC_URI[sha256sum] = "a99b39e7b04c333724f48c38fede709481cfb69fafe7e32ae4285b7fadf92f1b"
