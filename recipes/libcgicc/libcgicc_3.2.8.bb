require libcgicc.inc
EXTRA_OECONF += " --disable-demos --htmldir=${docdir}"
