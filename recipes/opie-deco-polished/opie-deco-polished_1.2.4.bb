require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_noncore_decorations_polished.tar.bz2;name=split_noncore_decorations_polished"
SRC_URI[split_noncore_decorations_polished.md5sum] = "0704552e7ffd05d7daba7921c7eb97fc"
SRC_URI[split_noncore_decorations_polished.sha256sum] = "0ff6ce60f085984d038d4c74281e7cf1796ccf479d4141ae1d1adc0936eb6033"
