require debianutils.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "cc768faa584f6c31cc1e0a959a3b8c0c"
SRC_URI[sha256sum] = "46c0991b71d1991aa2f90d6816d9efb737fc9f9b99713174fcdf8d323727a11c"
