require bc-cat.inc

