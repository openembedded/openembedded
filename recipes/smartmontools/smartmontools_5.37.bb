include smartmontools.inc

SRC_URI[md5sum] = "4ab3668b7d1362ce923f64a211e0e568"
SRC_URI[sha256sum] = "2984645b207c52ea9b8ef3951af8bd0c5aab469607fabf63ade05f8fe87309c1"
