include smartmontools.inc

SRC_URI[md5sum] = "f6f7380ae45587161c0adae8862110e9"
SRC_URI[sha256sum] = "725cfd59b33a97561346a990e1ec50b150dbac01f2b90cd9cf3fd74ff1e77720"
