include smartmontools.inc

SRC_URI[md5sum] = "53f6861a916169a88a9edb1848e27dd0"
SRC_URI[sha256sum] = "2fdde1b4e610cd6e004db8f98ac1100fcbea03b8f11e236de536ce22bc6c620d"
