PR = "r0"

SRC_URI = "${SOURCEFORGE_MIRROR}/linknx/linknx-${PV}.tar.gz \
           "

require linknx.inc

SRC_URI[md5sum] = "00d473efe99e117ff832f39d1eae7abc"
SRC_URI[sha256sum] = "01455fb9e041882ddd055da7a4f65854bae5331de5724b39f32beacd5c8ed8d4"
