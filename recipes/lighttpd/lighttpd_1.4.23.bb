require lighttpd.inc

PR = "${INC_PR}.1"

DEFAULT_PREFERENCE = "-1"

