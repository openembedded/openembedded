require lighttpd.inc

PR = "${INC_PR}.0"

DEFAULT_PREFERENCE = "-1"

SRC_URI[src.md5sum] = "3ce5be17a4dac3c384a8a452c664b840"
SRC_URI[src.sha256sum] = "08fc11864a0ad6d2871f32e6d0b0eaeb070f78698a72959f812526173145986e"
