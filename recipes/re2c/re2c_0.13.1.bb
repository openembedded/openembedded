require re2c.inc 

PR = "r0"

SRC_URI[md5sum] = "d6168a6c18d5912e98d9343b33fdad97"
SRC_URI[sha256sum] = "1a47035dd0f283dbc6c0964679afdf6f2c975b462419d1880ac379dc880ba74a"
