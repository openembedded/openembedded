require re2c.inc 

PR = "r0"

inherit native
