require re2c.inc 

SRC_URI[md5sum] = "4a97d8f77ed6d2c76c8bd840a43f5633"
SRC_URI[sha256sum] = "f3a995139af475e80a30207d02728b1e0065b0caade7375e974cb1b14861668c"
