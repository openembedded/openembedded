require openvpn.inc

PR = "r2"

SRC_URI[md5sum] = "9eab3719b280a12d19ef1fda286cc363"
SRC_URI[sha256sum] = "22072a24bcaef8038a1e84363f3e209f65eb7c7ab37741752172a334acb31fb8"
