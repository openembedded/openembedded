require openvpn.inc

PR = "r2"

SRC_URI[md5sum] = "60745008b90b7dbe25fe8337c550fec6"
SRC_URI[sha256sum] = "347c551e7c88affc1f4b7a4b715080253c9298dcc512ed29fe8ca5cd26d015d9"
