require openvpn.inc

PR = "r1"

SRC_URI[md5sum] = "7401faebc6baee9add32608709c54eec"
SRC_URI[sha256sum] = "063f00d5b889beee910eb113c8cfbb4fc85cd404693494bcaaf79dd09a98335c"
