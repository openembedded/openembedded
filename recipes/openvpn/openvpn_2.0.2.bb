require openvpn.inc

PR = "r1"

SRC_URI[md5sum] = "862f8788f080f669b1ae00a74ef68001"
SRC_URI[sha256sum] = "927512af1c0bc2af29690e205ce16c0cc920477be85742ebbedd8472ba01f807"
