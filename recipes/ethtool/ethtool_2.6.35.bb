require ethtool.inc
PR = "r1"

SRC_URI[md5sum] = "e0f617779a58b77af061a9e5178d0b25"
SRC_URI[sha256sum] = "be0a7b0fbe56fd455bcef24af7f047b02cefecfb422f4ebc3e4e924bce30e891"
