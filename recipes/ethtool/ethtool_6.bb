require ethtool.inc
PR = "r0"

SRC_URI[md5sum] = "3b721ec27f17ebf320ba8c505cf66d9c"
SRC_URI[sha256sum] = "5046f573e7dd77f689c33c5f0aa0f2b7f96c79e0b37d6ecc78bae74c094fb4c6"
