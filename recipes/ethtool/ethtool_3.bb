require ethtool.inc
PR ="r1"

SRC_URI[md5sum] = "b4e71f7fa2629250677eefcb338442c5"
SRC_URI[sha256sum] = "015d7c6084a668d7c2868d074e41a9cdd80bb6f0c7c6b9d275802e1629dd301f"
