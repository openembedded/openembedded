require ethtool.inc
PR ="r0"

SRC_URI[md5sum] = "3882c7c9cb9b4c37b08846dea9370245"
SRC_URI[sha256sum] = "4536d6bc9ce52b9f4d505ff36aefca23c1042a92fd2f9a54308eff6e09b1a22b"
