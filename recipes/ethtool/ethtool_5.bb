require ethtool.inc
PR ="r0"

SRC_URI[md5sum] = "5df7f165974e096e2de890e099f87a12"
SRC_URI[sha256sum] = "9eaad6076e57a5e2019733e4387705dc66829ea17cce04701b436cf5f374bb8f"
