require qemu_cvs.bb
require qemu-native.inc
require qemu-gcc3-check.inc

DEPENDS += "gcc3-native"
