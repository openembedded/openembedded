inherit native

require lzma.inc
PR = "${INC_PR}.1"
DEPENDS = "zlib-native"
