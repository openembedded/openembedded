require regexp_${PV}.bb

inherit java-native

