require avalon-framework-api_${PV}.bb

inherit java-native

