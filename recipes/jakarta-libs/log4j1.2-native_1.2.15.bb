require log4j1.2_${PV}.bb

inherit java-native

DEPENDS = "fastjar-native gnumail-native gnujaf-native"

