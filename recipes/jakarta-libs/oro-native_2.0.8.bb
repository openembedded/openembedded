require oro_${PV}.bb

inherit java-native

