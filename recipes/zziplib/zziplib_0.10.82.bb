require zziplib.inc

SRC_URI += "file://zziplib-0.10-disable-test.patch;patch=1"

PR = "r1"

SRC_URI[md5sum] = "a6538f6c44ceeed0ed7e8e356f444168"
SRC_URI[sha256sum] = "f684397ce39ec400ba3369521892b7c3a8711d3ef1be59115db9f8d57707bbb8"
