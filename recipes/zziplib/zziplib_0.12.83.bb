require zziplib.inc

SRC_URI += "file://zziplib-buildfix.patch;patch=1"

