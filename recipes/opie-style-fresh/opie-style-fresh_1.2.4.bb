require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_noncore_styles_fresh.tar.bz2;name=split_noncore_styles_fresh"
SRC_URI[split_noncore_styles_fresh.md5sum] = "cd9bc69de67f015282d87cc5dc70989c"
SRC_URI[split_noncore_styles_fresh.sha256sum] = "4cb1a0e38fa8ca70db25c0d1b9ec020d841cd1af8d59c9716b44191932ae4d1a"
