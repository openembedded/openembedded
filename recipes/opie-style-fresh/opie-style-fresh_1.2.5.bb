require ${PN}.inc

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_noncore_styles_fresh.tar.bz2;name=split_noncore_styles_fresh"
SRC_URI[split_noncore_styles_fresh.md5sum] = "92b32f2ea3773c9b010b322e725c5c42"
SRC_URI[split_noncore_styles_fresh.sha256sum] = "d25f5ae33658cc19621639041b2ada0e1ed0815aa06eb387c292e3c95be94579"
