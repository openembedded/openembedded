require flac.inc

PR = "r7"

SRC_URI += "file://disable-xmms-plugin.patch;patch=1"
