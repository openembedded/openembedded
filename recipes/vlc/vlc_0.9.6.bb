require vlc.inc
PR = "r1"

SRC_URI[md5sum] = "cd71276ed867029a6d077a40bccd4d05"
SRC_URI[sha256sum] = "ac091ba9b2e2e9aff293969b3405b145c09789e59ac0caab2247211a19e09a8a"
