# Copyright (C) 2009, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-addon.inc

PR = "${INC_PR}.1"

SRC_URI = "http://ftp.mozilla.org/pub/mozilla.org/addons/1568/full_fullscreen-3.3-fx.xpi"
EXTENSION = "{bfe3406c-6f31-4789-86d5-efa50e12c9eb}"
