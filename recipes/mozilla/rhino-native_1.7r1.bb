require rhino_${PV}.bb

inherit java-native

RDEPENDS_${PN} = ""
