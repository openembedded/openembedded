DEPENDS = "libgpewidget libgpelaunch gtk+"
SECTION = "gpe"
DESCRIPTION = "GPE windowlist applet"
LICENSE = "GPL"

PR = "r0"

GPE_TARBALL_SUFFIX = "bz2"

inherit autotools gpe





SRC_URI[md5sum] = "4aebe132c5365706266838a73d2bcd2d"
SRC_URI[sha256sum] = "4fcdbbfc8c965f93abee1d7b5c212e3f49b5daa6257271f10b40b3e81452b1aa"
