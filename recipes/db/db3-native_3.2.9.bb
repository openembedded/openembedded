SECTION = "libs"
VIRTUAL_NAME = "virtual/db-native"
CONFLICTS = "db-native"
inherit native
require db3_${PV}.bb

PACKAGES = ""
