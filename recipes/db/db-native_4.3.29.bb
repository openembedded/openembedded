require db_${PV}.bb
require db4-native.inc

SRC_URI[md5sum] = "200b9f5d74175875fcb3ee54adbf0007"
SRC_URI[sha256sum] = "a1fa714482f25a67a19490303a0164326ac63bd7653ae3f4664c2536b14f3337"
