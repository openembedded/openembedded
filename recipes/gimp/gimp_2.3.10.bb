require gimp.inc
PR = "r3"


SRC_URI[archive.md5sum] = "a46acb413484300583ffca1fa54e0874"
SRC_URI[archive.sha256sum] = "38ddc0ebc452968db653efce31864d61bc4a5e521a9694a8b9b8f4fe49a2d131"
