require gimp.inc
PR = "r1"

SRC_URI[archive.md5sum] = "393e7fb4e5e141faa2e3b44da3f301e3"
SRC_URI[archive.sha256sum] = "ea5cb59c739357003b3c7fb0d1166e8d8f913be6e9f4737c1905e62b93b0246f"
