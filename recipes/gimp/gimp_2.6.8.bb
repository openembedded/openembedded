require gimp.inc

DEPENDS += "webkit-gtk lcms gegl hal"

SRC_URI = "ftp://ftp.gimp.org/pub/gimp/v2.6/gimp-${PV}.tar.bz2 \
          "



SRC_URI[md5sum] = "a4d9462c9420954824a80c9b1963f9d9"
SRC_URI[sha256sum] = "d5d4218b742390157fca23a9d2cce436904546a2ea419ffeb44a5f43c99a3332"
