require gimp.inc


SRC_URI[archive.md5sum] = "9b5cc6aef0baca3735ce9bc4fdc949d9"
SRC_URI[archive.sha256sum] = "f4e388b7b52db1e91e052dcd0aeab0844fcf83a14ccd24228bf033e7937007f0"
