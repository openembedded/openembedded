require gimp.inc

DEPENDS += "lcms gegl hal"

SRC_URI = "ftp://ftp.gimp.org/pub/gimp/v2.6/gimp-${PV}.tar.bz2 \
          "


