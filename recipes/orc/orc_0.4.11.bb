require orc.inc

SRC_URI[orc.md5sum] = "b8b0b148d319422c3ad250c29483b3c4"
SRC_URI[orc.sha256sum] = "6ec60521a11339eda36f1e2210d08ae95010d769575e471aaf365b89bca8d031"
