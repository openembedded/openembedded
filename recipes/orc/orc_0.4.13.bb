require orc.inc

DEFAULT_PREFERENCE = "-1"

PR = "${INC_PR}.1"

SRC_URI[orc.md5sum] = "f6d0aed003f67c91933c22d9e5f1696a"
SRC_URI[orc.sha256sum] = "0fb8952ff688fe4b6f3b68cad49d4fb3cdfd28643b43410170601cc1f1e49601"
