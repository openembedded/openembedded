require orc.inc

SRC_URI[orc.md5sum] = "e26e59428b13ec251916f34bea96eee5"
SRC_URI[orc.sha256sum] = "4e04953643cd8e67f8d9796da9547a606954e3944e42e7ce5a099440fd8e729e"

