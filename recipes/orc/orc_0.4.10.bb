require orc.inc

PR = "${INC_PR}.0"

SRC_URI[orc.md5sum] = "dd4e7a1820c9db5853aa7fe31ddb5a03"
SRC_URI[orc.sha256sum] = "5001a0034edc06800b546246fbe0407ba6e9759c9583d5d93adba3557b6a777e"
