require orc.inc

SRC_URI[orc.md5sum] = "4006eb0ba85a69563952a65b5ea043a0"
SRC_URI[orc.sha256sum] = "aac7af5d37ce87b1d3d014822f2e2b6be83daff4d752f56a45766e5a807e6b53"

