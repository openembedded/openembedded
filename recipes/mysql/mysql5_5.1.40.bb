require ${PN}_${PV}.inc

DEPENDS += mysql5-native
