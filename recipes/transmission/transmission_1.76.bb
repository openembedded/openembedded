require transmission.inc


SRC_URI[archive.md5sum] = "ac44511ba4c203998be3079626126ede"
SRC_URI[archive.sha256sum] = "b221d6ecec0c5ca9908f17ae7d56ce139d317faaa0c106e99fb321130280f151"
