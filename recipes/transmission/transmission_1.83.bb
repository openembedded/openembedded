require transmission.inc

SRC_URI[archive.md5sum] = "fbdc151040ec64f55c3f28be60a21060"
SRC_URI[archive.sha256sum] = "f5678fe8127526d774a26262dc62ba432576d0df90dec1976a1bcab23e57b611"

