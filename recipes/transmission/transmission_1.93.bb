require transmission.inc

PR = ${INC_PR}.0

SRC_URI[archive.md5sum] = "f68358d03e46bec5704bbaa894990152"
SRC_URI[archive.sha256sum] = "e9b7b1fb9aad2808ee27b163dba8647f738c23513201864fa9944010b8d71670"
