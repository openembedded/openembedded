require transmission.inc

SRC_URI[archive.md5sum] = "00fe9cc2c4f8e004c89825812e387fc4"
SRC_URI[archive.sha256sum] = "51fa895c36cd5f01fa202ff3ca8a73d862db90687fdd35bcd1404ca70faf653d"

