require transmission.inc

SRC_URI[archive.md5sum] = "2c6993300988d5aa2e3fc24a439d3633"
SRC_URI[archive.sha256sum] = "716b86eeccb87d955094c341dec8299e4a33b4d3bf37f3969d4638c0a13a9e8b"

