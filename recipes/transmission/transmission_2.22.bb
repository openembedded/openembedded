require transmission.inc

DEPENDS += "libevent"

PR = ${INC_PR}.1

SRC_URI[archive.md5sum] = "6499986bf769276310b00bda1090090d"
SRC_URI[archive.sha256sum] = "5a4079194f45260c143f21ea6f33ce2660d89fca02ad8f1e65169968d365e4d4"

