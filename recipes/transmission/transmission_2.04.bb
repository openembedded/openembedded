require transmission.inc

DEPENDS += "libevent"

PR = ${INC_PR}.1

SRC_URI[archive.md5sum] = "84fe15eb7e000fdc369def513299358b"
SRC_URI[archive.sha256sum] = "c0010ee3f4d93d737da732bceb4e640dc404b0e7659980fb10dafb5bb0a83b4f"
