require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_development_keyview.tar.bz2;name=split_development_keyview"
SRC_URI[split_development_keyview.md5sum] = "bb5b3f4954713efbd23bf26089ccbc47"
SRC_URI[split_development_keyview.sha256sum] = "4d3d658014c6d9c3ed02e23725d0da65724250cf387a86c7c76bbc2acac0c1fc"
