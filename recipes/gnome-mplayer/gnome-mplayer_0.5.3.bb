require gnome-mplayer.inc

PR = "r4"
SRC_URI += "http://dekorte.homeip.net/download/${PN}/${P}.tar.gz"
