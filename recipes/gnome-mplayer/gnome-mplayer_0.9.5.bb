require gnome-mplayer.inc

PR = "r5"
