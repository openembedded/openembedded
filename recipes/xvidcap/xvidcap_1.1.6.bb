require xvidcap.inc

PR = "r0"


SRC_URI[md5sum] = "c6add7ae452e5cecbdda6e55e7c67cdb"
SRC_URI[sha256sum] = "17ca7b7f8ce12f7e312b2abc2da7f381dc0e964cdac6312631cd7987f02b9fba"
