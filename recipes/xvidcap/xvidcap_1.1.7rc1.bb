require xvidcap.inc

PR = "r0"

# 1.1.7rc1 still uses this directory name
S = "${WORKDIR}/${PN}-1.1.6"

SRC_URI[md5sum] = "449ee23b6ea171f090b9de48ffefb364"
SRC_URI[sha256sum] = "487bf07b2f9ead6a59682d091081e47cfe4ca5777de32e6cec5bef55fa51c82f"
