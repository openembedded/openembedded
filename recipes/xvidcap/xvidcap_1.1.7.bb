require xvidcap.inc

PR = "${INC_PR}.0"

S = "${WORKDIR}/${PN}-1.1.7"

SRC_URI[md5sum] = "b39a682d3ef9fcbf424af771936780e2"
SRC_URI[sha256sum] = "154622801e8d5e91b834e7707e9e1cc65cf20d0161f6e0323bc3bf0efd85195d"
