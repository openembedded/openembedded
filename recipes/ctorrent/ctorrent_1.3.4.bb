require ctorrent.inc
PR = "r6"

SRC_URI += "file://extended_ctorrent.diff;patch=1"

SRC_URI[md5sum] = "823010ec78215d476537c9eba9381cdd"
SRC_URI[sha256sum] = "7e2ef5d0656ac23cecd03374d9b00291a55b274c972adfe94d6f41ae3ba60c73"
