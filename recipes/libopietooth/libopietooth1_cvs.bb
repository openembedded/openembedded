SRC_URI = "${HANDHELDS_CVS};module=opie/noncore/net/opietooth/lib"
PV = "${OPIE_CVS_PV}"
PR = "r2"

require libopietooth1.inc
