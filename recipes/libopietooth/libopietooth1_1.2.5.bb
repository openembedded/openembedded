SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_noncore_net_opietooth_lib.tar.bz2"
PR = "r0"

require libopietooth1.inc
