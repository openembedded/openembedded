SRC_URI = "${HANDHELDS_CVS};tag=${TAG};module=opie/noncore/net/opietooth/lib"
PR = "r1"

require libopietooth1.inc
