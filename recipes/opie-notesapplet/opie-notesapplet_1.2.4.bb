require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_noncore_applets_notesapplet.tar.bz2;name=split_noncore_applets_notesapplet"
SRC_URI[split_noncore_applets_notesapplet.md5sum] = "5e60456b21fe994ba0f05027690782d2"
SRC_URI[split_noncore_applets_notesapplet.sha256sum] = "faf7e4fb0821cc1f4754057a225ef697862938a6f9997cce067928667662ccf8"
