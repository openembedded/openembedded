require rdiff-backup.inc
PR = "r1"

SRC_URI[md5sum] = "756b38aaf2602d097cafd08996fb7887"
SRC_URI[sha256sum] = "e754605b72b5498d11207920291d0eed6fa78ad46d3b9ad018cff9bb480224ea"
