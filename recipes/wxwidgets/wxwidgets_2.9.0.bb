require wxwidgets-${PV}.inc

PR = "${INC_PR}.0"
