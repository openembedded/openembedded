require qpf.inc

DESCRIPTION = "Helvetica fonts - QPF Edition"
HOMEPAGE = "http://www.pobox.sk/~mico/zaurus.html"
LICENSE = "GPL QPL"
PR = "r2"

SRC_URI = "http://www.openzaurus.org/download/3.5.4/sources/qpf-helvetica.tar.bz2"
S = "${WORKDIR}/helvetica"

SRC_URI[md5sum] = "20c040a004f4949b6849658148a78388"
SRC_URI[sha256sum] = "4b6a122b4f95cf90f9639ca423947e70bba4e567099f9baeada419a51b11924b"
