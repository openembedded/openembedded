require qpf.inc

DESCRIPTION = "Hunky Sans font - QPF Edition"
HOMEPAGE = "http://www.yoper.com/ariszlo/hunky.html http://sourceforge.net/projects/hunkyfonts"
LICENSE = "LGPL"
PR = "r6"

SRC_URI = "http://www.openzaurus.org/download/3.5.4/sources/${PN}-${PV}-r4.tar.bz2"

S = "${WORKDIR}/${PN}"

SRC_URI[md5sum] = "917d7f8f3ad3c5b94c747b37d0a5e74a"
SRC_URI[sha256sum] = "c3cdd8f234cbc1694af777dc1739ca4439cd472567d85f333dc11264d6bda7c8"
