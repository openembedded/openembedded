require qpf.inc

DESCRIPTION = "Utopia fonts - QPF Edition"
HOMEPAGE = "http://www.pobox.sk/~mico/zaurus.html"
LICENSE = "GPL QPL"
PR = "r2"

SRC_URI = "http://www.openzaurus.org/download/3.5.4/sources/qpf-utopia.tar.bz2"
S = "${WORKDIR}/utopia"

SRC_URI[md5sum] = "fa2563f3c2332c5bcb05add075908f1e"
SRC_URI[sha256sum] = "599eed45edc9942f4b37858507c2223cb8decb13fea180cf33c6961ad48a33d1"
