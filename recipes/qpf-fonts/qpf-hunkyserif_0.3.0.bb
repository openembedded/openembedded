require qpf.inc

DESCRIPTION = "Hunky Serif font - QPF Edition"
HOMEPAGE = "http://www.yoper.com/ariszlo/hunky.html http://sourceforge.net/projects/hunkyfonts"
LICENSE = "LGPL"
PR = "r6"

SRC_URI = "http://www.openzaurus.org/download/3.5.4/sources/${PN}-${PV}-r4.tar.bz2"

S = "${WORKDIR}/${PN}"

SRC_URI[md5sum] = "02b38aeaf30c17e15b714b9594ca504d"
SRC_URI[sha256sum] = "3c5890d6b0aee2d4c1e0c6b8101b6b5381985e86bc50dffc338b8601f4aa7ae8"
