require foxtrotgps.inc

SRC_URI[md5sum] = "73f03ba1ee1853dea077aa18518222f7"
SRC_URI[sha256sum] = "c7fffa0d45f59de0b858c84e57a6325af78f97f3492ef5e4bd75d5bf0c20d689"
