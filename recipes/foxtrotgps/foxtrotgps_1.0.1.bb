require foxtrotgps.inc

SRC_URI[md5sum] = "982d14cdb0439cc4d6aa6cefc232124d"
SRC_URI[sha256sum] = "059158fd8e61137e2e6d6e01685add7fb85cce8483faa99efb01187f2ba50841"
