require foxtrotgps.inc

SRC_URI[md5sum] = "1b9f5959740e3bbeb4b232aa7f0fcbee"
SRC_URI[sha256sum] = "24f789294ae4f4251adccdb5f0c677b3fd6dea9bce2b6a17497f87a0dc3d056a"
