require bluez4-libs.inc

PR = "${INC_PR}"

SRC_URI += "file://avinfo-link.patch;patch=1;pnum=0"
