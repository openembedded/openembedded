require bluez-libs.inc

SRC_URI[md5sum] = "4b3403f1c61f7b7758cabf1ac5cb5092"
SRC_URI[sha256sum] = "04ad733f88662470906a6f0d9894f670a07573f7f7d2698c5ada70b3ae1ba3da"
