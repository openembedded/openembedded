require bluez4-utils.inc

PR = "${INC_PR}"
