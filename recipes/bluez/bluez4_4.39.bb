require bluez4.inc

PR = "${INC_PR}.1"


SRC_URI[md5sum] = "ba06291b737077332e914d6d653501c6"
SRC_URI[sha256sum] = "924dc4b8ae78da2c8f3af9c36ab85d08ee7f8ec0ae4dfe58840ae70041580063"
