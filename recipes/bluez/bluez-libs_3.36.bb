require bluez-libs.inc

PR = "r1"

SRC_URI[md5sum] = "8c2ca546c0e7bb73dbd0e906fce7f6b1"
SRC_URI[sha256sum] = "692f994d8479143c18e781f9afa6c8265770a5affbf2e6147edc70b78aa3bfae"
