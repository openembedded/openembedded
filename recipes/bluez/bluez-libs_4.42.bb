require bluez4-libs.inc

PR = "${INC_PR}.1"
DEFAULT_PREFERENCE = "-1"
