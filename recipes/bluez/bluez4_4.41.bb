require bluez4.inc

PR = "${INC_PR}.1"

