require dialog.inc
PR = "${INC_PR}.0"

