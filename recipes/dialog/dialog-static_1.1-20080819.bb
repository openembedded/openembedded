require dialog.inc
LDFLAGS += "-static"
S="${WORKDIR}/dialog-${PV}"
