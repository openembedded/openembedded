include ibrdtn.inc

SRC_URI = "http://www.ibr.cs.tu-bs.de/projects/ibr-dtn/nightly-builds/archives/ibrcommon-${PV}.tar.gz"

SRC_URI[md5sum] = "4da2d4a1f8141caeae5b5e8eb1d3aaa2"
SRC_URI[sha256sum] = "e4514f67967e72d1edc412147a7175c92627fd266a741d72add58fe2f7daaf2a"
