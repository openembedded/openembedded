include ibrdtn.inc
DEPENDS += " ibrdtn ibrcommon "
SRC_URI[md5sum] = "4abdc469356f3a50c51f979567c52b1d"
SRC_URI[sha256sum] = "12655518c7772c97094abbd808a1f412ce81dd1889b2ef5ebf5b24845d53289a"
