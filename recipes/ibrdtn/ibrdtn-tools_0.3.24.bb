include ibrdtn.inc

DEPEND += "ibrdtn"

SRC_URI = "http://www.ibr.cs.tu-bs.de/projects/ibr-dtn/nightly-builds/archives/ibrdtn-tools-${PV}.tar.gz"

SRC_URI[md5sum] = "a93f23c6f0ae4421f91cc1711ae5762d"
SRC_URI[sha256sum] = "2eb0b8f17f44a792f2f64ce47b0eb3c9005d5802f582a900da6d3b0b631d4a79"
