include ibrdtn.inc

DEPENDS += "ibrdtn"

SRC_URI = "http://www.ibr.cs.tu-bs.de/projects/ibr-dtn/nightly-builds/archives/ibrdtnd-${PV}.tar.gz"

SRC_URI[md5sum] = "be4f804a303690029d26fce249479a61"
SRC_URI[sha256sum] = "30b6c53be8dd201d056fedde783fa6faa5dd80266a1b5a4622e071be398abf2f"
