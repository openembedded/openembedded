include ibrdtn.inc
DEPENDS += " ibrdtn ibrcommon "

SRC_URI[md5sum] = "4ecf5560b56f15600ee0360b7f6ef840"
SRC_URI[sha256sum] = "2ed86eadbfdfbc266a2001608dc4296bc14aa7ba4c12c022b79d9e23fffa9226"
