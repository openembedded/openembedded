include ibrdtn.inc

DEPENDS += "ibrcommon"

SRC_URI = "http://www.ibr.cs.tu-bs.de/projects/ibr-dtn/nightly-builds/archives/ibrdtn-${PV}.tar.gz"

SRC_URI[md5sum] = "2e446611601803f15ab5dade39b210a6"
SRC_URI[sha256sum] = "3b124a5ac0e5e529c2c7b46928fd9102eca83e1e596a6a1a2f67933eeff3111f"
