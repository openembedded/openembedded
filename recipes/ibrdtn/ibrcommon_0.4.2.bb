include ibrdtn.inc

SRC_URI[md5sum] = "7bc9b8c454239af138f0959ba8d38190"
SRC_URI[sha256sum] = "18f93592b7f0a606cabf258f5609d6a38a790bc084e0c6ce3f4691f8ca26cf14"
