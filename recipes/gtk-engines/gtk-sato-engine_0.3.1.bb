require gtk-sato-engine.inc

PR = "r4"

SRC_URI = "http://pokylinux.org/releases/sato/sato-engine-${PV}.tar.gz"
S = "${WORKDIR}/sato-engine-${PV}"

SRC_URI[md5sum] = "4f889f5bd5976f808c77c497b069c8f1"
SRC_URI[sha256sum] = "a6f9081b7637bfca057f9759b51822440564ba8f7b809d917baee985d45a193a"
