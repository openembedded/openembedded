require libxsettings-client.inc

PR = "r1"

SRC_URI = "${GPE_MIRROR}/xsettings-client-${PV}.tar.bz2"

SRC_URI[md5sum] = "63e6c23e5a2036cfba77bd22c9a7bff2"
SRC_URI[sha256sum] = "33237bb8fdad27e7f9fef9122198654e4e39081582baeb60ca4246308ffa4eb2"
