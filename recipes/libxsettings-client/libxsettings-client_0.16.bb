require libxsettings-client.inc

SRC_URI += "        file://Makefile-am.patch;patch=1"


PR ="r2"

SRC_URI[md5sum] = "bd572a17dce9bb5826441a8d1d5f3da5"
SRC_URI[sha256sum] = "1622c837f0a7fef79b523b07d936bb807404974610a239cf3ada04fce2b13a11"
