RDEPENDS = "python-shell"

inherit distutils-base

require ${PN}-${PV}.inc
