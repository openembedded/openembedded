require mumudvb.inc

SRC_URI[md5sum] = "a463af541d0395ba3a2286e92f080615"
SRC_URI[sha256sum] = "0b3921762dabac062bba5b086fe5661e98526f8ea2b1719aad0fb40128d7111b"
