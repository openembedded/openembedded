require ${PN}.inc

PR = "r0"

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_freetype.tar.bz2;name=split_freetype"
SRC_URI[split_freetype.md5sum] = "cda4da0c8f622cc4020e7020bcd426f7"
SRC_URI[split_freetype.sha256sum] = "804624e97cdccad3c9b6bd072a84d4e8d5afe955701fd149c2d8c54c586a2efd"
