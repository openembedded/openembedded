require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_freetype.tar.bz2;name=split_freetype"
SRC_URI[split_freetype.md5sum] = "4fbe668e5f8f9698a8f969e90fe2ce21"
SRC_URI[split_freetype.sha256sum] = "7a5e0a52aec342a4ec8994244b9f40ea73a71d4435fa80edc996c478f2261b0f"
