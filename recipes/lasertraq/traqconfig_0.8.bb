require lasertraq.inc


FILES_${PN} += "${datadir}/gnome ${datadir}/traqConfig"
FILES_${PN}-doc += "/usr/doc/"


SRC_URI[md5sum] = "c24cc9ba196b32134186843324bfe784"
SRC_URI[sha256sum] = "7a2162c783f98a2de9658a217cd0409a7bd16d40040c34a6077df376a2135aea"
