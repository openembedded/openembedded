require vala.inc
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "17df64cc716969453e43c09910746abd"
SRC_URI[archive.sha256sum] = "0830b1f7f3001a28d4014d60183dedc7f9f8a299d04747ed9b274639c84d8184"

