require vala.inc

FILES_${PN} += "${datadir}/vala-0.12/vapi"

SRC_URI[archive.md5sum] = "8b458f145d98df00124eb45db43391f5"
SRC_URI[archive.sha256sum] = "4080f0e7c5634fba9fbf85d9851b2f9106c72ad1eb5dc2c036eed73396d4ac90"
