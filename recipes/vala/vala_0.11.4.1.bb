require vala.inc

FILES_${PN} += "${datadir}/vala-0.12/vapi"

SRC_URI[archive.md5sum] = "c3aba299a360c894fee281c53bb2a624"
SRC_URI[archive.sha256sum] = "0d9a45472c4dd5c18c8797b7627b62d3f93a92a6cefabfd7224ed15ce1ed3802"

