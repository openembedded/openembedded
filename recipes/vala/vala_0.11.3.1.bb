require vala.inc

FILES_${PN} += "${datadir}/vala-0.12/vapi"

SRC_URI[archive.md5sum] = "9f208c5e466a31e974c63a56f97a707c"
SRC_URI[archive.sha256sum] = "2e698782327f45cdd4d6c604bcf2d4f58669c5e76de71fe6a158566354020b92"

