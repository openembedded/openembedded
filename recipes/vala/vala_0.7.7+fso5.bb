require vala.inc
PR = "r0"

SRC_URI = "http://www.freesmartphone.org/sources/vala-${PV}.tar.bz2"
