require vala.inc
inherit native

DEPENDS = "glib-2.0-native"
PV = "0.7.2+0.7.3-fso1"

SRC_URI = "http://www.freesmartphone.org/sources/vala-0.7.3-fso1.tar.gz"
S = "${WORKDIR}/vala-0.7.3-fso1"
