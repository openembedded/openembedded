require vala.inc

FILES_${PN} += "${datadir}/vala-0.12/vapi"

SRC_URI[archive.md5sum] = "0d0f99311e5812a618f6b22a6299dcb5"
SRC_URI[archive.sha256sum] = "5662d489126a00b04270f09585846aa82b688c9a202c438179723003ae6dbee1"

