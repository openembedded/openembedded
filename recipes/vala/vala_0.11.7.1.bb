require vala.inc

FILES_${PN} += "${datadir}/vala-0.12/vapi"

SRC_URI[archive.md5sum] = "8d0e7c610f0cc9643210737efba4023c"
SRC_URI[archive.sha256sum] = "4ccefd97be310f1270995337e1f7615bc381078af794f36e407422200a9c3be7"
