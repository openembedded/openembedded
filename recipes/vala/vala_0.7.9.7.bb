require vala.inc
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "b05fd8f4420152ca0080a99750863f3f"
SRC_URI[archive.sha256sum] = "46805e1c19707de043820a1474a8b3775ea3b698a0b539eabd7b86f0f3ad888a"
