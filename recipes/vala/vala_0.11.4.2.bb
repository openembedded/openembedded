require vala.inc

FILES_${PN} += "${datadir}/vala-0.12/vapi"

SRC_URI[archive.md5sum] = "f973d0c1b9bf36274084a52ce19e8104"
SRC_URI[archive.sha256sum] = "a795fe2ff2be7e719cd19ad749d3a0cce453a194d811ffab325a7e5b6c4baf29"

