require vala.inc
inherit native
DEPENDS = "glib-2.0-native"

PR = "${INC_PR}.0"

