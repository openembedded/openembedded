require vala.inc
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "ab9b4d59816a28e2a2118516e937d32e"
SRC_URI[archive.sha256sum] = "a641df1ee84c6ee70bf7a747b46aad12ffa24c6c4093e9a46c5ae0675f2b028f"
