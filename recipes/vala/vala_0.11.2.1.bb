require vala.inc

FILES_${PN} += "${datadir}/vala-0.12/vapi"

SRC_URI[archive.md5sum] = "0f56b0609aa1158cb8c07524227d17e8"
SRC_URI[archive.sha256sum] = "61954eb631c7c5a063a41c4cfa9eb5e89667deaef8c19fc974a2099a16c8393a"
