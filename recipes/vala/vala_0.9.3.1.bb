require vala.inc
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "4ebf3a224cdbd3e73bc1786bcbf5bead"
SRC_URI[archive.sha256sum] = "9448861683f596b0ab5938baa1e6b19b535fe78d73a3fe043e57cee8d79dc2f6"
