require vala.inc
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "8c51fca23c0f3b97a41f95091eecede0"
SRC_URI[archive.sha256sum] = "c2a70074885ad7f86bef3455bf6080b6a550078455930dc7f6fd0db603af522b"
