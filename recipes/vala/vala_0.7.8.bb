require vala.inc
PR = "r0"

SRC_URI = "http://download.gnome.org/sources/vala/0.7/vala-${PV}.tar.bz2"
