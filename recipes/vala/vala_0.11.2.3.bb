require vala.inc

FILES_${PN} += "${datadir}/vala-0.12/vapi"

SRC_URI[archive.md5sum] = "7650a398af148af2abfc4d591203effd"
SRC_URI[archive.sha256sum] = "bcb84253b4381d773b2d7453f41e89706ae7a7b5e205384736fb58cf9c60edaa"

