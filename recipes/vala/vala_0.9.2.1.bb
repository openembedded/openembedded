require vala.inc
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "5ae63f0f89dffbf4a377b9fdfb46348d"
SRC_URI[archive.sha256sum] = "fe4228cf00c298299d4037b40d3d7b494b0b965f435677f10878efa1e22bd9b2"

