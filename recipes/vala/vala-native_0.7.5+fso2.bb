require vala.inc
inherit native
DEPENDS = "glib-2.0-native"

VALA_FSO_RELEASE = "0.7.5-fso2"
PV = "0.7.4+${VALA_FSO_RELEASE}"
PR = "${INC_PR}.0"

