require vala.inc
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "ef5b292a880c98e3dfe00c59773db936"
SRC_URI[archive.sha256sum] = "f29d0257722983d58627f0d788cf7ed7223658cc30bfd01555fd958d59a46584"
