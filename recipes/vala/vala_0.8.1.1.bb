require vala.inc
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "5135c4ea472269de59121b3380bcf1cd"
SRC_URI[archive.sha256sum] = "07fcd4140ef24dc9977aef89eab023e9e2814be4baee5e210dcdce64d084743e"
