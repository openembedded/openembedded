require vala.inc

FILES_${PN} += "${datadir}/vala-0.12/vapi"

SRC_URI[archive.md5sum] = "d2fe497ba64c4b5a23460450689a0b76"
SRC_URI[archive.sha256sum] = "b5610b54177cc8bfa77424e1c142b303a5bc09d73d509b182627c8f3c6967652"

