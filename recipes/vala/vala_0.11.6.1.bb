require vala.inc

FILES_${PN} += "${datadir}/vala-0.12/vapi"

SRC_URI[archive.md5sum] = "3d99f6d122d312335c9db04b57e7f2ca"
SRC_URI[archive.sha256sum] = "4bdb5ce571e930cca371d89cb511dea5d5e53bb1c317130ecde59fb6963a81e5"
