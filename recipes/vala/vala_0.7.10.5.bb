require vala.inc
PR = "${INC_PR}.0"
SRC_URI[archive.md5sum] = "5ee5b86460181e9bb0de9cb2e8f35077"
SRC_URI[archive.sha256sum] = "1c4830973dbca36f8826e490ec8477df6ced0c8675bd724e24494ca0f1616926"
