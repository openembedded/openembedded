require vala.inc

SRC_URI[archive.md5sum] = "93d3e223c8ff35361b9dc9960bfec1bd"
SRC_URI[archive.sha256sum] = "2cedf5a56bb4a52a2ba403a7c4d069074fc0b1c133ae18b4de2862bd6236aff8"

