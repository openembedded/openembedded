require vala.inc
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "8ae482f5dcff847b86bdd79f442dd2cd"
SRC_URI[archive.sha256sum] = "9a56b12abda181f08cd4c60b60a5b78a026d5289b9a164aa16a3226e1427cda8"

