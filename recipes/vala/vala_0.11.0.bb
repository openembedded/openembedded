require vala.inc

SRC_URI = "http://download.gnome.org/sources/vala/0.11/vala-${PV}.tar.bz2"
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "55290a999b08734ff36e73fddfeeeda0"
SRC_URI[sha256sum] = "7bd0add719a49e3ea1a6ff4431d637216274d5363b9704781a5d955298963c8d"
