require vala.inc
inherit native

PR = "r0"

DEPENDS = "glib-2.0-native"

SRC_URI = "${GNOME_MIRROR}/vala/0.7/vala-${PV}.tar.bz2"
