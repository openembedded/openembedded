require vala.inc
inherit native

PR = "r0"

DEPENDS = "glib-2.0-native"

SRC_URI = "http://www.freesmartphone.org/sources/vala-${PV}.tar.bz2"
