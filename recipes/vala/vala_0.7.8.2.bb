require vala.inc
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "02ff1049f0fadf6cd384414c9c714f67"
SRC_URI[archive.sha256sum] = "8cb781887fd91ecfa2ea2089942bb113d85ce78b5059d02278e907eef261f1b5"
