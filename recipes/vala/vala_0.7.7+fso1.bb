require vala.inc
PR = "r2"

SRC_URI = "http://www.freesmartphone.org/sources/vala-${PV}.tar.bz2"
