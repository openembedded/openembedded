require vala.inc
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "142bac4b488bfb828f9e215c46fadcdf"
SRC_URI[archive.sha256sum] = "3a31a1d3c275769d0a6b99aabcbd86d4b66e9c3a72868762e9e7c39ac2bc5cff"
