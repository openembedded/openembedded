require vala.inc
DEPENDS = "vala-bootstrap-native"
PR = "r0"
