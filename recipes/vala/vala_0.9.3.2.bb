require vala.inc
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "aee9ec6a9eab9b4a5412081a9efa25e1"
SRC_URI[archive.sha256sum] = "52421f6c4a8aa24b71c6730ee9f3cdfd536a61c9afebf939eb930254de208770"

