require vala.inc
VALA_FSO_RELEASE = "0.7.5-fso2"
PV = "0.7.4+${VALA_FSO_RELEASE}"
PR = "${INC_PR}.0"


