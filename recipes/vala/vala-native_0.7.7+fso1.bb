require vala.inc
inherit native
DEPENDS = "glib-2.0-native"

PR = "${INC_PR}.0"

SRC_URI = "http://www.freesmartphone.org/sources/vala-${PV}.tar.bz2"
