require vala.inc
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "01c93c64e11f79bd08ab0bd6cdf4fbbc"
SRC_URI[archive.sha256sum] = "6888d438f0b9f314c36a94a0e114711614b55df6227545504c13909992ddd412"
