require vala.inc

FILES_${PN} += "${datadir}/vala-0.12/vapi"

SRC_URI[archive.md5sum] = "d8e877de2cc61ab71f2ba576860fba85"
SRC_URI[archive.sha256sum] = "10fa0b416d561c3aaef311badd687cb085d2d0c865c4708f3b23edec01d1d9df"

