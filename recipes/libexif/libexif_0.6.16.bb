require libexif.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "deee153b1ded5a944ea05d041d959eca"
SRC_URI[sha256sum] = "db6885d5e40e3a273ff8bb9708ab739c8ace3c5abdd75509eec8ea31a31aac43"
