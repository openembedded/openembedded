require libexif.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "56144a030a4c875c600b1ccf713f69f7"
SRC_URI[sha256sum] = "f97695261cc269c2d370ea1737985feaa8b4cadf34b8839005930afdd701cabd"
