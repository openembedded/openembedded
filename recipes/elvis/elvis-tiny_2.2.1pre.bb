require elvis_${PV}.bb
require elvis-tiny.inc
