require ${PN}.inc

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_noncore_decorations_flat.tar.bz2;name=split_noncore_decorations_flat"
SRC_URI[split_noncore_decorations_flat.md5sum] = "9fa386eca38c67a4abcf65d8966dd127"
SRC_URI[split_noncore_decorations_flat.sha256sum] = "6e441ae34a8af51b6c6ce7ba0e7d2da574abb4d0c86fd8c8bf19b690ecebbf6d"
