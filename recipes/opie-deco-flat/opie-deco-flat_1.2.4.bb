require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_noncore_decorations_flat.tar.bz2;name=split_noncore_decorations_flat"
SRC_URI[split_noncore_decorations_flat.md5sum] = "a92ad7b0daae8a19e71cef66d67e0bf5"
SRC_URI[split_noncore_decorations_flat.sha256sum] = "11967d87dce2de2ce99d62e62e72201418da8ad560e286bf3a690710ec4a1306"
