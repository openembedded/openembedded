inherit qt4x11

SRC_URI[arora.md5sum] = "ccef0f214e0f03828cde8c521f7a5225"
SRC_URI[arora.sha256sum] = "7b5bdbb01dccc27776c65f7aa7e4557c5ac23b07494d935523ffce7d7cece9da"

require arora.inc
