inherit qt4x11

SRCREV = "27a630a74518ebb7810ed5886182e676b36c07a5"
require ${PN}.inc
PR = "${INC_PR}.0"
