inherit qt4e

require arora.inc
