inherit qt4x11

require arora.inc
