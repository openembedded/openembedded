inherit qt4e

require qtwebkit-performance-utilities.inc
PR = "${INC_PR}.0"
