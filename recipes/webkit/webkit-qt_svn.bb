require webkit-qt.inc
inherit qt4x11
