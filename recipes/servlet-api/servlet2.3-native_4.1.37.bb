require servlet2.3_${PV}.bb

inherit java-native

