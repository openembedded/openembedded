require autofs.inc

SRC_URI = "${KERNELORG_MIRROR}/pub/linux/daemons/autofs/v3/autofs-${PV}.tar.bz2"
PR = "${INC_PR}"
