require jzlib_${PV}.bb

S = "${WORKDIR}/jzlib-${PV}"

inherit java-native

