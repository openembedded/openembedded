require libtinymail.inc

SRC_URI[md5sum] = "de3fd5f8c838ba9c876783d21ebf43bb"
SRC_URI[sha256sum] = "e234d314f0bdfcc54f52111519624fcd3d1ff37a267c39848b5de7a272367976"
