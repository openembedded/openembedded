require libmatthew.inc

PR = "r0"

SRC_URI = "http://pkgs.fedoraproject.org/repo/pkgs/libmatthew-java/libmatthew-java-0.7.1.tar.gz/6a4db221129f230c64a0f937d00bb703/libmatthew-java-${PV}.tar.gz \
           file://Makefile-0.7.patch"



SRC_URI[md5sum] = "6a4db221129f230c64a0f937d00bb703"
SRC_URI[sha256sum] = "003c44be21859d1495c0571e249ce17edd5ac58636f67b6a8bc4f395a6c7e6a2"
