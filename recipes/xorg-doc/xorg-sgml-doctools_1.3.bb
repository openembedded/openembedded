require xorg-doc-common.inc
PE = "1"

FILES_${PN} += " /usr/share/X11/sgml"

SRC_URI[archive.md5sum] = "1e3ee108688d1df91049a565813c973d"
SRC_URI[archive.sha256sum] = "d5c0279fa84dc4a61ba2a6a9a892b34b7e9266f9562721b529b0296f5b75dbb2"
