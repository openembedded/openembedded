require xorg-doc-common.inc
PE = "1"

FILES_${PN} += " /usr/share/X11/sgml"

SRC_URI[archive.md5sum] = "f930e5be117922f0841614c8d43f1ae8"
SRC_URI[archive.sha256sum] = "4def78f2e0e002f5693b61b53ab4325fbc150d3614fe53818e8df9b365a4dbea"
