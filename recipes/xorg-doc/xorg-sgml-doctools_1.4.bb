require xorg-doc-common.inc
PE = "1"
SRC_URI[archive.md5sum] = "20484c9d97800530616742cb14989ac2"
SRC_URI[archive.sha256sum] = "e49b069c03cdc9d7a8aa23054431660fc2360213768a3defe61f8f9ee0af4d6f"
FILES_${PN} += " /usr/share/X11/sgml"
