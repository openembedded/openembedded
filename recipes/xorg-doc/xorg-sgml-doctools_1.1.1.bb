require xorg-doc-common.inc
PE = "1"

FILES_${PN} += " /usr/share/X11/sgml"

SRC_URI[archive.md5sum] = "ae3d4f73c42953b0a5513bb2967ab913"
SRC_URI[archive.sha256sum] = "be1fbd7646a55eb9a9ad161f9b83034ba88a82c780e29d4a7888db2495947f25"
