# This package builds the devio program for the build architecture
require devio_cvs.bb
require devio-native.inc
