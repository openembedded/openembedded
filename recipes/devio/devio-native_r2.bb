# This package builds the devio program for the build architecture
require devio_r2.bb
require devio-native.inc
