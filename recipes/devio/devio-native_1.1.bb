# This package builds the devio program for the build architecture
require devio_1.1.bb
require devio-native.inc

SRC_URI[md5sum] = "fe2319ec57b6363c1da78a435ef714c5"
SRC_URI[sha256sum] = "92984b9f18488d020459873c18503a08a3942469b510e7c0b6be73c590df7b39"
