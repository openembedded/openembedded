# This package builds the devio program for the build architecture
require devio.inc
require devio-native.inc
