require libpcap.inc

PR = "r3"

SRC_URI += "file://aclocal.patch;patch=1"

SRC_URI[md5sum] = "5208f24d0328ee7c20b52c43eaa9aa0e"
SRC_URI[sha256sum] = "c4158398de4411627b14f52626e4cef39443f4d5c1b9bce8c07f8526d18362f9"
