require libpcap.inc

PR = "r2"

SRC_URI[md5sum] = "0ad921c881fdd3d278046afcd352a151"
SRC_URI[sha256sum] = "f20d19b1f32e4ee465169ff1e17a3755bfda8c697cfed11fe36cbf6959c80441"
