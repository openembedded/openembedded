require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_core_pim_today_plugins_mail.tar.bz2;name=split_core_pim_today_plugins_mail"
SRC_URI[split_core_pim_today_plugins_mail.md5sum] = "eab7fd33168fe5fd31a788f1b76f077c"
SRC_URI[split_core_pim_today_plugins_mail.sha256sum] = "b44b9c325ad675f9cb8e7c360b5b297f1850ce2cf56f1b816dc6a4291f6bd389"
