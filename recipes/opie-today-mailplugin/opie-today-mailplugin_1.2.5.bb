require ${PN}.inc

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_core_pim_today_plugins_mail.tar.bz2;name=split_core_pim_today_plugins_mail"
SRC_URI[split_core_pim_today_plugins_mail.md5sum] = "37669d11f41c1ca1761044abe5e631ba"
SRC_URI[split_core_pim_today_plugins_mail.sha256sum] = "10d318c7bde2bd08dcdb167e0240545293c1f86b824ce60517883388a933a3cc"
