require ${PN}.inc

RDEPENDS = "irda-utils"

inherit gpe


SRC_URI[md5sum] = "a22e4b7ca7d5730e564cb92146de4b86"
SRC_URI[sha256sum] = "656685f167454f577a5b6441ffb55a51d38b53a4b449fde7758a80852cfc0bc7"
