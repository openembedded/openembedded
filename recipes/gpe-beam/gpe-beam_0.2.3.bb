require ${PN}.inc

RDEPENDS = "libopenobex-1.0-1"

inherit gpe pkgconfig
