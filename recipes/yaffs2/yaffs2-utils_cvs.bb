require yaffs2-utils.inc

