require gdb.inc
LICENSE = "GPLv2"

PR = "r2"

SRC_URI[md5sum] = "7dc98022ee96bba5331f195dc8a5491a"
SRC_URI[sha256sum] = "719f2bbd79d55cdd6f5e31b49cec49df71ddb32a4439dba678de0e09330096da"
