require gdbserver.inc

LICENSE = "GPLv2"

PR = "${INC_PR}.0"
