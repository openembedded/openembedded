require gdbserver.inc

LICENSE = "GPLv3"

PR = "${INC_PR}.1"
