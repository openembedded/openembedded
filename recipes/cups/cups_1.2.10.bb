require cups.inc

PR = "r3"

