require automake.inc
PR = "${INC_PR}.0"

DEFAULT_PREFERENCE = "-1"

SRC_URI[automake.md5sum] = "c11b8100bb311492d8220378fd8bf9e0"
SRC_URI[automake.sha256sum] = "8eccaa98e1863d10e4a5f861d8e2ec349a23e88cb12ad10f6b6f79022ad2bb8d"
