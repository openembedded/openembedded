require automake.inc
PR = "${INC_PR}.0"
