require automake.inc
PR = "${INC_PR}.0"

SRC_URI[automake.md5sum] = "b8e67fb458da396bc35555af7ef2b49f"
SRC_URI[automake.sha256sum] = "e98ab43bb839c31696a4202e5b6ff388b391659ef2387cf9365019fad17e1adc"

