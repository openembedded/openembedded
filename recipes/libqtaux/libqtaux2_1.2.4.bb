require ${PN}.inc
PR = "${INC_PR}.1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_libqtaux.tar.bz2"
