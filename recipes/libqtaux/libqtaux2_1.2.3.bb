require ${PN}.inc
PR = "${INC_PR}.0"

SRC_URI = "${HANDHELDS_CVS};tag=${TAG};module=opie/libqtaux"
