require ${PN}.inc

PR = "r0"

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_libqtaux.tar.bz2;name=split_libqtaux"
SRC_URI[split_libqtaux.md5sum] = "4d9148573545948870358e3612be18ba"
SRC_URI[split_libqtaux.sha256sum] = "0acfa28d3f43c1a990fea30c2306053d42664fa196c68b20e009ac6408ff04f8"
