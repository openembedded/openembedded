require libsexy.inc
PR = "r0"

SRC_URI[md5sum] = "495d8d986f0caa23b001f8e09d11eaf3"
SRC_URI[sha256sum] = "835265bb0d39689e8a8580b5ffb53222b3f5f483d58aa533a5c7ebfc3d273d50"
