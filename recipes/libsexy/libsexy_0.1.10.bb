require libsexy.inc
PR = "r0"

SRC_URI[md5sum] = "c009b0c89e5cf91dba17261f4cccfc4c"
SRC_URI[sha256sum] = "e7720307f3fafb210963b6d91c608f25ae2088880260b3e39508c27aab13a3a0"
