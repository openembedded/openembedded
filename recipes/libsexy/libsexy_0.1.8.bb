require libsexy.inc
PR = "r1"

SRC_URI[md5sum] = "ddc52cc8196f9f0bf48a5c7569b6bb38"
SRC_URI[sha256sum] = "83e82b9afe296584a6c9f1f8b3e3a70d324209021e0049f68d28bd1de8c18136"
