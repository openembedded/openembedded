PR = "r2"

MAP_NAME = "San Francisco"
require om-maps.inc

MAP_FN = "om-maps-san-francisco-${PV}.eet"
MAP_VER = "${PV}"

SRC_URI[md5sum] = "c23e48390885391a3b403c8d7863e031"
SRC_URI[sha256sum] = "a7f00540ac487fa26050a2aaf5a9b7fbb82af0a32c6f5d60043d4228a652151e"
