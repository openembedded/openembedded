PR = "r1"

MAP_NAME = "Hong Kong"
require om-maps.inc

MAP_FN = "om-maps-hong-kong-${PV}.eet"
MAP_VER = "${PV}"

SRC_URI[md5sum] = "fdb477186a9a8deb6f62b93e2fd8ab72"
SRC_URI[sha256sum] = "bb8b04b2befc76ad913cd1f8d4bb90764a13ce3ea015c51bdcdf553184c36a77"
