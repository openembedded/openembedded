PR = "r2"

MAP_NAME = "Buenos Aires"
require om-maps.inc

MAP_FN = "om-maps-buenos-aires-${PV}.eet"
MAP_VER = "${PV}"

SRC_URI[md5sum] = "306c1d9537f510b30273a030f5ace118"
SRC_URI[sha256sum] = "8486baf16bbc6dd4ad3820330a28546996f9383de96c1b6bf784999dcf4b712e"
