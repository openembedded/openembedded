PR = "r2"

MAP_NAME = "Berlin"
require om-maps.inc

MAP_FN = "om-maps-berlin-${PV}.eet"
MAP_VER = "${PV}"

SRC_URI[md5sum] = "25b515f30606b3f78d5d77c96663185d"
SRC_URI[sha256sum] = "3ebb791e9bf6b00127b4961d8f15b4d1e48d209468b01365300d3ea5a5cacf37"
