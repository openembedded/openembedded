PR = "r2"

MAP_NAME = "Sydney"
require om-maps.inc

MAP_FN = "om-maps-sydney-${PV}.eet"
MAP_VER = "${PV}"

SRC_URI[md5sum] = "5b83060995bade39a80dafb83571f627"
SRC_URI[sha256sum] = "66150243fa43052fc762ec1d5d141b44c98a49bec49f726c7db7c54968d605c5"
