PR = "r2"

MAP_NAME = "New York"
require om-maps.inc

MAP_FN = "om-maps-new-york-${PV}.eet"
MAP_VER = "${PV}"

SRC_URI[md5sum] = "3fd0065397e6ae78d43b159a3e9d3660"
SRC_URI[sha256sum] = "43df4b1407baf3b647e30abf7e5461d86c3145d6df21f4d27a2fb2d8b2b08ec9"
