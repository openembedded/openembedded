PR = "r2"

MAP_NAME = "Paris"
require om-maps.inc

MAP_FN = "om-maps-paris-${PV}.eet"
MAP_VER = "${PV}"

SRC_URI[md5sum] = "f93c90a1cfaf3113a1577331582c0cd1"
SRC_URI[sha256sum] = "b27f67834142417e35dc911fa51f13595bb3271800b9963ed481749bbb17466b"
