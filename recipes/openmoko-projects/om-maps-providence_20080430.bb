PR = "r2"

MAP_NAME = "Providence"
require om-maps.inc

MAP_FN = "om-maps-providence-${PV}.eet"
MAP_VER = "${PV}"

SRC_URI[md5sum] = "105cd93f37409631fd99d23cdd033420"
SRC_URI[sha256sum] = "ca2a91115445ce8dfb758099158e31425695181909e94f928feef6077a6cba0a"
