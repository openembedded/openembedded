PR = "r1"

MAP_NAME = "low levels"
require om-maps.inc


MAP_FN = "om-maps-low-levels-${PV}.eet"
MAP_VER = "${PV}"

SRC_URI[md5sum] = "c4e4fe25075d3843b6a8430e78321c4e"
SRC_URI[sha256sum] = "de7bba6c6418782f3af45e8a5988b1d945f276bcc6f1174107b66c7d27316727"
