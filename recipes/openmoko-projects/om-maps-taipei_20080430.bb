PR = "r2"

MAP_NAME = "Taipei"
require om-maps.inc

MAP_FN = "om-maps-taipei-${PV}.eet"
MAP_VER = "${PV}"

SRC_URI[md5sum] = "5e82e0fb27f1ae480c5099f3bd572cf3"
SRC_URI[sha256sum] = "5dafd06260fe58847fb92f2e063f8fb0ae8ad4a3fb082f0871217d3ba88b162c"
