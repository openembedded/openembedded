PR = "r2"

MAP_NAME = "London"
require om-maps.inc

MAP_FN = "om-maps-london-${PV}.eet"
MAP_VER = "${PV}"

SRC_URI[md5sum] = "fa05427d09f98ea6cbceaa4c88f4c51d"
SRC_URI[sha256sum] = "1776ba1ec93984d0ff755a677a769e200a6e435fd1385e699e106c9cec83b04c"
