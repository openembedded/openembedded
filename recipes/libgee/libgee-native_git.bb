require libgee_git.bb
inherit native
