DESCRIPTION = "Niebiee - extremely blue theme for SHR (metapackage)"
SECTION = "x11/data"
RDEPENDS += "e-wm-theme-illume-niebiee elementary-theme-niebiee shr-splash-theme-niebiee"
PV = "0.1"
PR = "r1"

ALLOW_EMPTY = "1"
