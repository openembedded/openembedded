DESCRIPTION = "Sixteen SHR theme"
SECTION = "x11/data"
RDEPENDS_${PN} += "e-wm-theme-illume-sixteen elementary-theme-sixteen"
PV = "0.1"
PR = "r1"

ALLOW_EMPTY = "1"
