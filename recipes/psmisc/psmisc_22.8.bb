require psmisc.inc
PR = "r0"

SRC_URI[md5sum] = "32c493bb484ce605a1cabba1aa084bca"
SRC_URI[sha256sum] = "db304ec5349564acc484d84df283466c37ff6938c420d928db1d199121097e8c"
