require psmisc.inc
PR = "r2"
SRC_URI += "file://signames-header-fix.patch;patch=1"

SRC_URI[md5sum] = "d6276e071c10ddf4b0d98856e5573e1a"
SRC_URI[sha256sum] = "495463860415171d9019798ed4fdf5848ffe93f8a380662a39dd2690a04717ed"
