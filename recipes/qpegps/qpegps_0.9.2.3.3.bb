require qpegps.inc

PR = "r1"

SRC_URI[md5sum] = "974ff064b13640329da21f565ac351e6"
SRC_URI[sha256sum] = "5b070799c3eebf1dd94b1d800da0d532d2e9c353e061d4addc3466232e4a3072"
