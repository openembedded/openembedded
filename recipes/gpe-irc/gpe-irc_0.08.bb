inherit gpe pkgconfig
LICENSE = "GPL"
DESCRIPTION = "31337 IRC client."
DEPENDS = "gtk+ libgpewidget"
SECTION = "gpe"
PRIORITY = "optional"

SRC_URI[md5sum] = "0f934a03d8c4d18a9a977ff704a741c5"
SRC_URI[sha256sum] = "4731b10ca33f1a4cdf01dea88144d602bc23a8f5a8f12d925b59ce56e837b79c"
