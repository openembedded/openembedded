require kdepimpi_${PV}.bb

require pwmpi.inc
