require kismet.inc

PR = "r3"

SRC_URI[md5sum] = "a1dcea71f0c3f881ef72f5bca2db7b39"
SRC_URI[sha256sum] = "1b998b34e2e9377f5ac7704295d64507234fe7656e49d384f8bf95604e97e05b"
