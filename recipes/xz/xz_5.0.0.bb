require xz.inc
PR = "${INC_PR}.0"
SRC_URI = "http://tukaani.org/xz/xz-${PV}.tar.bz2"
SRC_URI[md5sum] = "0652c09fdbb93ae2ce78c1368ffda612"
SRC_URI[sha256sum] = "47a89e65c4690364a0123871a221e663d23a9fbd1ca756a804b10dd4006056d8"
