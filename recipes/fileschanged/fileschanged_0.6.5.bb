require fileschanged.inc
SRC_URI[fileschanged-0.6.5.md5sum] = "49ae8bed507c000f9c7fa430b5b71205"
SRC_URI[fileschanged-0.6.5.sha256sum] = "63c10995197bca6a7f24a19ca26870abafc919b23a870447cb44199d22f777cc"