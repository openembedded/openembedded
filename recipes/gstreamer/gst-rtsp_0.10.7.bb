require gst-rtsp.inc

SRC_URI[md5sum] = "3c2e0bf09bb66e302b6c64cb9e8f1eb6"
SRC_URI[sha256sum] = "53f352442db7b802248ea239b702e5db7e8fb5fe852f90e4e73c90204aa759c5"
