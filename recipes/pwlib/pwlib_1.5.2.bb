require pwlib.inc

PR = "${INC_PR}.1"

#seems like this very old source has vanished upstream
SRC_URI = "http://www.angstrom-distribution.org/unstable/sources/pwlib_1.5.2.tar.gz"
