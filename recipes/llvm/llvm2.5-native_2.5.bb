require llvm-native.inc

SRC_URI += "file://fix-build.patch;patch=1"

