require gpsdrive.inc

PR = "r2"

SRC_URI = "http://www.gpsdrive.de/packages/${PN}-${PV}.tar.gz \
           file://gpsdrive.desktop"

SRC_URI[md5sum] = "28b13b7253c8f019433be68686070558"
SRC_URI[sha256sum] = "5f53807375473b00f3748456fc8de33e7af300686032d74557fe5f0a931b3227"
