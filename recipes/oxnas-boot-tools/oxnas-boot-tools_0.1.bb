require oxnas-boot-tools.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "707b66dfc49278b310c1e837f8c99d76"
SRC_URI[sha256sum] = "02e896dceb3c052034e94d634f7e3ebc0514991f1a855b2de354410f77f17061"
