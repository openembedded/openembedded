PV = "4.1.2"
require gmp-native.inc

SRC_URI[gmp.md5sum] = "ed39b34dd14014cc504840776af5ba10"
SRC_URI[gmp.sha256sum] = "51ba8551092510ef5c61798584f4cff054e0fbbe7c46fea2c8ff9ea9a52edcd1"
