PV = "4.2.1"
require gmp-native.inc

SRC_URI[gmp.md5sum] = "091c56e0e1cca6b09b17b69d47ef18e3"
SRC_URI[gmp.sha256sum] = "d07ffcb37eecec35c5ec72516d10b35fdf6e6fef1fcf1dcd37e30b8cbf8bf941"
