require gmp.inc

SRC_URI += "file://gcc-compile.patch;patch=1"