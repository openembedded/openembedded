require ${PN}.inc

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_noncore_styles_web.tar.bz2;name=split_noncore_styles_web"
SRC_URI[split_noncore_styles_web.md5sum] = "8355646e8df0e04866152c7cfa7449dc"
SRC_URI[split_noncore_styles_web.sha256sum] = "5cadd510d0a42b4bd05cfdf344b90a36ad14f8a478ba4dcce2e2a25900f08dd0"
