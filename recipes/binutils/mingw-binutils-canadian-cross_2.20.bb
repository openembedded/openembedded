require mingw-binutils_${PV}.bb
require binutils-canadian-cross.inc

DEFAULT_PREFERENCE_mingw32 = "1"
