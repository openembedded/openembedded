require binutils_${PV}.bb
require binutils-cross-sdk.inc
PR = "${INC_PR}.1"

SRC_URI[md5sum] = "09a8c5821a2dfdbb20665bc0bd680791"
SRC_URI[sha256sum] = "3e8225b4d7ace0a2039de752e11fd6922d3b89a7259a292c347391c4788739f6"
