require binutils_${PV}.bb
require binutils-cross-sdk.inc
PR = "${INC_PR}.0"
