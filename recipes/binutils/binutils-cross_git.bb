require binutils_git.bb
require binutils-cross.inc
FILESPATHPKG =. "binutils-git:"
