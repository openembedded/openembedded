require binutils_${PV}.bb
require binutils-cross-sdk.inc
PR = "${INC_PR}.1"

SRC_URI[md5sum] = "4a4cde8e5d0c97249bf6933f095813fe"
SRC_URI[sha256sum] = "c4ad801a7ed5a4e3d5d943d73c82f0af75998c95b69184dc884460bf40e48ee9"
