require binutils_${PV}.bb
require binutils-cross-sdk.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "ee2d3e996e9a2d669808713360fa96f8"
SRC_URI[sha256sum] = "e1df09f0aa3b50154ef93bfefe86d65d01c22cfb44d73299ad95e772133a75b0"
