require mingw-binutils.inc
S = "${WORKDIR}/binutils-${PV}-src"
