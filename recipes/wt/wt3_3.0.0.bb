require wt3.inc

PR = "${INC_PR}.1"

SRC_URI += "file://noqt.patch;patch=1"

