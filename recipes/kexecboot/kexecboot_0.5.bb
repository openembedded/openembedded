PR = "r1"

SRC_URI = "http://projects.linuxtogo.org/frs/?group_id=50/kexecboot-${PV}.tar.gz "

require kexecboot.inc
