include zlib.inc

PR = "${INC_PR}.0"

SRC_URI += "file://0001-autotools.patch "

SRC_URI[md5sum] = "be1e89810e66150f5b0327984d8625a0"
SRC_URI[sha256sum] = "239aead2f22f16bfcfa6a6a5150dcbd6d6f2e4d1eaa8727b5769ea014120b307"

DEFAULT_PREFERENCE = "-1"
