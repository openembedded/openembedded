require zlib_${PV}.bb
LIB_EXTRA = ""

inherit sdk
