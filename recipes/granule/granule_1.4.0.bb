require granule.inc

MINVER = "7"
S = "${WORKDIR}/${P}-${MINVER}"
