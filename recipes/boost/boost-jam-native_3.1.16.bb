include boost-jam-native.inc

PR = "${INC_PR}.1"

SRC_URI = "${SOURCEFORGE_MIRROR}/boost/boost-jam-${PV}.tgz"


SRC_URI[md5sum] = "1fd96a38b1a33c365e8142eec53197e7"
SRC_URI[sha256sum] = "e681f9ba5d622e0c98c249d3847359a12292a7bcc5769f6e1a35e930f7306f25"
