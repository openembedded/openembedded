include boost-jam-native.inc

PR = "${INC_PR}.1"

SRC_URI = "${SOURCEFORGE_MIRROR}/boost/boost-jam-${PV}.tgz"


SRC_URI[md5sum] = "b86fb56a824d4a3dedcbda12f8b1a2b3"
SRC_URI[sha256sum] = "6cdb945ac41b5ac78e05435e742b3a9928e5d1a5ff22728656deff29249edc66"
