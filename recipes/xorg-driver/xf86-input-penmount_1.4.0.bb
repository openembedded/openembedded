require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- Penmount input driver"
PE = "1"
SRC_URI[archive.md5sum] = "d5f1395b2dcefc7533ff5580e63f2066"
SRC_URI[archive.sha256sum] = "8cb15e9a30f3602d22eba6c7bcca2c1040889ed0851c7b575273671c2da1bff1"
