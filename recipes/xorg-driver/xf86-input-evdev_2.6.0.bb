require xorg-driver-input.inc
DESCRIPTION = "X.Org X server -- evdev input driver"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "f33fe9413bde68936d8909206a13e8a1"
SRC_URI[archive.sha256sum] = "b0e7f3991a8183a4743196c3e16d7184d439b80bf43653aa2f45b0756a6753ac"
