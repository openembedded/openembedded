require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- Penmount input driver"
PE = "1"
SRC_URI[archive.md5sum] = "e5984e43ce31d45659eb6ee91c02aba5"
SRC_URI[archive.sha256sum] = "6f281a7bce9db34772bcf762eb0ed57b8121a204a6f15d5405fe870a0af57182"
