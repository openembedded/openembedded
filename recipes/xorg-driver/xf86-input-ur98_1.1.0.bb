require xorg-driver-input.inc
PE = "1"
SRC_URI[archive.md5sum] = "3cf8928411458baaa9e726e51772c550"
SRC_URI[archive.sha256sum] = "214bceb0fd52a932d448ce03d66539eed2e6660617e3d42977704cb7eec6472a"
