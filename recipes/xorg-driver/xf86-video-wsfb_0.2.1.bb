require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- wsfb display driver"
PE = "1"
SRC_URI[archive.md5sum] = "c159af867a9af3abc4da332189213a76"
SRC_URI[archive.sha256sum] = "39e358aa17d939f561a28c82b9e7beca202d7ebd7d40d401c88a9dff3d90d148"
