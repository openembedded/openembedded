require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X.Org X server -- Chips display driver"
SRC_URI[archive.md5sum] = "a3969c28c3b36ab2caa852a9324e9b70"
SRC_URI[archive.sha256sum] = "ff6fef2cffc62feb3b23f3fee375e502ab7356d571517a89b4de67f0f6037f0e"
