require xorg-driver-video.inc
DESCRIPTION = "X.Org X server -- Chips display driver"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "7aed07116e56c0630f62d7d34d7526e1"
SRC_URI[archive.sha256sum] = "fb6dc34a8d7db82dc6d555cebe6f95c2269dda4872118978345f6e1215ab4d25"
