require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- Penmount input driver"
PE = "1"
SRC_URI[archive.md5sum] = "268af4dceda544d8c815b9b7e87d4536"
SRC_URI[archive.sha256sum] = "fab08de727da6f56b82d8ecee451a52e7129ff80522e711c5322f1bd2fa9970a"
