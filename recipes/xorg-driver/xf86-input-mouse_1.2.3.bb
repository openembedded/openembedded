require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- mouse input driver"
PE = "1"
SRC_URI[archive.md5sum] = "47da1fa52584933d045528109f094eff"
SRC_URI[archive.sha256sum] = "a07cb2169f43018c90b7889781c0db30cda0da03811edccb8c4db533166357ab"
