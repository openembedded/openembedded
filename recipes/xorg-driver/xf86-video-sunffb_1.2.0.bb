require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "816842de26bce8a935f3c9c3cfedbc42"
SRC_URI[archive.sha256sum] = "59f2f8fc2399a4d6b0ce733481c58694e723a989f4712c00436d35e27c059292"
