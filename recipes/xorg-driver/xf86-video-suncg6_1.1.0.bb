require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "aa6b7836fe6ccc99994bf15ff2b74e86"
SRC_URI[archive.sha256sum] = "d6b1f3b79c57ef5281e0204b2847812cf9fa5df616478f01591445a36537194b"
