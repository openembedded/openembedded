require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- NV display driver"
PE = "1"
SRC_URI[archive.md5sum] = "c3e8c98287dc98677bebfbe1ba51ab77"
SRC_URI[archive.sha256sum] = "825ffb97525517de9f0ff7155946c6e58c278dba11957573cc970dd3b094f94a"
