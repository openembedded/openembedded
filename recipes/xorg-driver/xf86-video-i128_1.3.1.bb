require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- i128 display driver"
PE = "1"
SRC_URI[archive.md5sum] = "3b170a6df5114420cd4021a057918a09"
SRC_URI[archive.sha256sum] = "49bb23625654ebcd74d0d23f534b074188f4b21c3cd443b06ac83b9485bf9a75"
