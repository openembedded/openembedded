require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- NV display driver"
PE = "1"
SRC_URI[archive.md5sum] = "4401c7b956e60a6d7de68ca6a8ec05d0"
SRC_URI[archive.sha256sum] = "4286f8994d80a30c7b6b4fc9df6ea5d587f648adc23cb3f523f571738c6900f4"
