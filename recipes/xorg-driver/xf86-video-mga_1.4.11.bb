require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- MGA display driver"
PE = "1"
SRC_URI[archive.md5sum] = "9d1ca965cedb0856296b47442f3c739d"
SRC_URI[archive.sha256sum] = "c91922316f486f74d41ddbda92ff94a7917cea151ad802cf25603ab6b90f97e6"
