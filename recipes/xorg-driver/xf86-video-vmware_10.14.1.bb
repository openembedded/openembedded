require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X11 driver for VMware SVGA Device"

#DEPENDS += " "
SRC_URI[archive.md5sum] = "eaf1ce9fa23363799140602afaa10f37"
SRC_URI[archive.sha256sum] = "1971fd356ba54204c3611edb9144c43c25c21167a5fa5ee725d3f2e3f9864fa9"
