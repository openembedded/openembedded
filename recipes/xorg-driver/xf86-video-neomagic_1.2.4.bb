require xorg-driver-video.inc

PE = "1"

DESCRIPTION = "X11 driver for NeoMagic 2200, 2160, 2097, 2093, 2090, 2070"

DEPENDS += " xf86dgaproto"

