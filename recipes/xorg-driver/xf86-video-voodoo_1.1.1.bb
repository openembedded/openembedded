require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X11 driver for Voodoo/Voodoo2"

DEPENDS += " xf86dgaproto"
