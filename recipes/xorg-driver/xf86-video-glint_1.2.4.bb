require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- Glint display driver"

DEPENDS += " xf86dgaproto drm xf86driproto"

SRC_URI[archive.md5sum] = "960df34e129faa411e58c0d6b56d79a3"
SRC_URI[archive.sha256sum] = "5f8d6e3b02c261d235bae63d95510b940b6c9a775301146b3c229926ed99d76f"
