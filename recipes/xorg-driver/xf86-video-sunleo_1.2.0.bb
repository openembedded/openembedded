require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "14fe008620940a674981912fa02ae133"
SRC_URI[archive.sha256sum] = "b315be97197020ae352efe48e9bcd13a572c3a03b2a4d598e89157a897746e06"
