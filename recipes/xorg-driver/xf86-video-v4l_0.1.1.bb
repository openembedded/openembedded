require xorg-driver-video.inc

PE = "1"

DESCRIPTION = "Video 4 Linux adaptor driver for X11"
SRC_URI[archive.md5sum] = "69339c38eba2cebc357d67e7a755d734"
SRC_URI[archive.sha256sum] = "33ad549ea3f6a8da7f58d9964f3f2d83aabc6d64c2ebc2ea0033ac8dacaec870"
