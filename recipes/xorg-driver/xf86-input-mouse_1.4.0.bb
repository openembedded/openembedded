require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- mouse input driver"
PE = "1"
SRC_URI[archive.md5sum] = "e7dc0759c14a9bfd373917a49e5f7c7d"
SRC_URI[archive.sha256sum] = "e6e1dbd64d41c826619a5881c5aeed46095bfdcb87c3e27d65292fc12a5bb7c7"
