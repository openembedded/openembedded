require xorg-driver-video.inc
PE = "1"

#DESCRIPTION = ""

#DEPENDS += " "
SRC_URI[archive.md5sum] = "f98fc22142a009dc3a6cdf930c95203f"
SRC_URI[archive.sha256sum] = "1090d9100934329000ac330d0c66a0ac4f60d2ba83196ea15c2833a28a18b1e3"
