require xorg-driver-input.inc
DESCRIPTION = "X.Org X server -- evdev input driver"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "eceb6dc517c0649b772f18708a1aade8"
SRC_URI[archive.sha256sum] = "9dec173ac9d8d09ef5cb2f79e74471f5f3ddd108827f3e95958b623766260333"
