require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "66344e315def275605dafb314ce59851"
SRC_URI[archive.sha256sum] = "5988962199d5013274f6a6952939e4f405df658bb6616ebf9954c993b1179b1b"
