require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- MGA display driver"
PE = "1"
SRC_URI[archive.md5sum] = "3e80cfb84b62866d2f94774ecbf3e46c"
SRC_URI[archive.sha256sum] = "e8efee8d5269eb29f9bd499db3d47a6a4d3c320d4b0a24874cdf7b598ad77a5c"
