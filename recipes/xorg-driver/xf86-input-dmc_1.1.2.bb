require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- DMC input driver"
PE = "1"

SRC_URI[archive.md5sum] = "91021ea8f3593221c0d9ee9cc14deb48"
SRC_URI[archive.sha256sum] = "b6f4eb367ab1aa7da5ac5218953d7cdde409c9ddf59f6cb6b2e1aa2789b3f361"
