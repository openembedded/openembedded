require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "bb6c4def5cfb0959b72dccb661473d4a"
SRC_URI[archive.sha256sum] = "d56fe98c34f2af1b6424e3fcaa22a31402a4b59d63679f0e5fdfb1d2ea878419"
