require xorg-driver-input.inc
PE = "1"

DESCRIPTION = "X.Org X server -- muTouch input driver"
SRC_URI[archive.md5sum] = "f28998cdfae2a4c41589299a4ee1f459"
SRC_URI[archive.sha256sum] = "53bfe976042de69f87e28261ad581cf418c67b5cb69a09cfe1eea169021db35b"
