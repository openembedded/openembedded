require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- evdev input driver"
PE = "1"
SRC_URI[archive.md5sum] = "f56d98ab11ef77cfcbafb5d93c697791"
SRC_URI[archive.sha256sum] = "71e896168819bcf50044c175482d03873c31bc6eb355305a87e94772580789dd"
