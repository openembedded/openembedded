require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "8e4bd0a6b155cb861356e7430d667aee"
SRC_URI[archive.sha256sum] = "cb43007920394b000be98ea0eac16a1cc16b4ca7ea8532b5d803a0c7574720d8"
