require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- joystick input driver"
PE = "1"
SRC_URI[archive.md5sum] = "ff25ea697cfa1570cc28f4b9cf9c761f"
SRC_URI[archive.sha256sum] = "1d33b9668e039ea9adc0680c1f2971785508cfd74b2215749db23af23ef8f9ce"
