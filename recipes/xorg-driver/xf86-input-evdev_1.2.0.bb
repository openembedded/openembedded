require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- evdev input driver"
PE = "1"
SRC_URI[archive.md5sum] = "0c7c41d3f1637bb559e80c2ad708f05d"
SRC_URI[archive.sha256sum] = "b23b231d754cab717a4b145ee3a5f3e73db46d877d23502326e9794d92d976ba"
