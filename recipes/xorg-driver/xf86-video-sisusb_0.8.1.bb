require xorg-driver-video.inc
DEPENDS += " xineramaproto xf86miscproto"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "cbd669507e4aa35e468905f09b546333"
SRC_URI[archive.sha256sum] = "1596b79ab3e33263bde2d456cc0376808abee80b4cde059605f176d98bdb45cb"
