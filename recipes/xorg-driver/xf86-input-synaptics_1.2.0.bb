require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- mouse input driver"
PE = "1"
SRC_URI[archive.md5sum] = "2cf0a2b0b3006bcfcd85bb77d966244a"
SRC_URI[archive.sha256sum] = "ddd5ad4c25ad2f2e46134272bf047522882deba8ac3ac04d5e11f8bd9718620c"
