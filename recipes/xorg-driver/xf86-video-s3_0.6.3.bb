require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X.Org X server -- legacy S3 display driver"
SRC_URI[archive.md5sum] = "5eb06d88533fb327d067928faeb20860"
SRC_URI[archive.sha256sum] = "ed9f65aa6eb1811d8c16cddfce00c5fc5880d6d46b907a83ef77700610085144"
