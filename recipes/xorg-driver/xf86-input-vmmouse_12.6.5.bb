require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- VMMouse input driver to use with VMWare"
PE = "1"

COMPATIBLE_HOST = 'i.86.*-linux'

SRC_URI[archive.md5sum] = "ce78e0135b5e34338a1ea98afb933120"
SRC_URI[archive.sha256sum] = "381ac3b9dc47f7bb425b4748fc9945e9c70054e40d71aedcd5327b5834d68c0d"
