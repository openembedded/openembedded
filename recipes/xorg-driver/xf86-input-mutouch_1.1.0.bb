require xorg-driver-input.inc
PE = "1"
SRC_URI[archive.md5sum] = "98ae915c67cabf0e6d40a425dbdbe10b"
SRC_URI[archive.sha256sum] = "cc67e0dd4f4fcc8d798f0bfe42b975132c5739bdd80809580a74182e4d1b62ea"
