require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X.Org X server -- legacy S3 display driver"
SRC_URI[archive.md5sum] = "d05e7c3cb044437eda8663e174ba913c"
SRC_URI[archive.sha256sum] = "ed07e4648b0f405fddd563783b49f971d649dd07cc8bc7737a93ff3d90f6c067"
