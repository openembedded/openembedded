require xorg-driver-input.inc
PE = "1"

SRC_URI[archive.md5sum] = "1fe53cd055a69650f3c2e02377ec728c"
SRC_URI[archive.sha256sum] = "26cfa755d3a383f80039fcd286c44ba5f7b353feb8c674f386bb08d741d2c3fe"
