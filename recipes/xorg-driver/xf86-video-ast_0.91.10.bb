require xorg-driver-video.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "65da53af3ebd1685149b6145976fdb2d"
SRC_URI[archive.sha256sum] = "7e1b1490f894677f616c0215a7d5fb7d6c5355ce393cf5dc9c9ab4b635b8cc15"
