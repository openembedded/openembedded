require xorg-driver-input.inc
PE = "1"

SRC_URI[archive.md5sum] = "e1bcbdefcb839173de79aeb3cd038b77"
SRC_URI[archive.sha256sum] = "c5ca8fb2dfe0130767b2c10bd0661277a67e7d5b9171a7f5f6264ec48790473f"
