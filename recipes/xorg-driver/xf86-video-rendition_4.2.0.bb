require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X11 driver supporting cards based on the V1000 or the V2x00."

#DEPENDS += " "
SRC_URI[archive.md5sum] = "7c03de3804d4c4f6ff59f74050d24b2b"
SRC_URI[archive.sha256sum] = "b57b62f707d87534a799170e31b33311449cfd7019a56e6b4fa85a4c7faaae15"
