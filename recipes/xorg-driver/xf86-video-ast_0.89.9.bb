require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "619f6ff15db869be3800bb001d5b0468"
SRC_URI[archive.sha256sum] = "880f16d32a373a052515f4ae28a3f1a97543d0d73d2ea5d74baf23bdc3a6b401"
