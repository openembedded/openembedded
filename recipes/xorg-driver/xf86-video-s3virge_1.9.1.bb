require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "a91c73285ef67ee7cd9e2da28acb6cc4"
SRC_URI[archive.sha256sum] = "cef5702963f49e737fb8b1472dc0241f7a5da49f844ac77f2df3e693a84bc822"
