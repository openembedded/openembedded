require xorg-driver-input.inc

DESCRIPTION = "X.Org X Server -- Citron input driver"
PE = "1"

SRC_URI[archive.md5sum] = "4e254fcefb3bea55772e63c12570f6d9"
SRC_URI[archive.sha256sum] = "1480ba63b342c00a53292d513bd79a69e1ea7c01a0c77d1a368ffb22e37c1a83"
