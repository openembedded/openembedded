require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "22b7cc20a33443cbd218bd2521850cfe"
SRC_URI[archive.sha256sum] = "46013885696f3c1a5e05c5d503abc69e691443319a97cf2c6a01ec031e06c910"
