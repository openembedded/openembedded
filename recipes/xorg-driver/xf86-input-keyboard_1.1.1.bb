require xorg-driver-input.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " kbproto"

SRC_URI[archive.md5sum] = "babf094e37bdfc08076d4adb4c69c1d9"
SRC_URI[archive.sha256sum] = "b7e7377d75f3a10cceb5df18019b8e4498fbed0100478edd4af75bf8cd45d6fd"
