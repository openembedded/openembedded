require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "Number Nine I128 for X11"

#DEPENDS += " "
SRC_URI[archive.md5sum] = "c483efc90b1935025b17e4b9e9c2e4df"
SRC_URI[archive.sha256sum] = "b52183f5a7d0adee1d21b4b0a0908886b7bbc69dc4498f1e7a3edc4b1988c41c"
