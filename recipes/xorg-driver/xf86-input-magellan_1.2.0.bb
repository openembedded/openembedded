require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- Magellan input driver"
PE = "1"
SRC_URI[archive.md5sum] = "9801ba10f15f8be2420dfb3f3b5d5d27"
SRC_URI[archive.sha256sum] = "c5285147a4df0b5b0fd5dcb7c0e5953bc982d3d6f2a2ed2e7767ead909a510e4"
