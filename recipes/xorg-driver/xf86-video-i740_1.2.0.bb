require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- i740 display driver"

PE = "1"
SRC_URI[archive.md5sum] = "d0e5a805c546b29b1dd3b55a68d16dc4"
SRC_URI[archive.sha256sum] = "59c8f6ee465bef033c1c20bfff8121a318efda9656d5dc29f674bb655f18486f"
