require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "02ed7d5215610a3463a0307b30bb5425"
SRC_URI[archive.sha256sum] = "d6a66778e0f6ddd907cba5784386bd6bb526f773b5db9faa35875ba67c2ca6ad"
