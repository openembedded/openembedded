require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- mouse input driver"
PE = "1"
SRC_URI[archive.md5sum] = "939f1c831c5cd3a6f027e982592dfc5b"
SRC_URI[archive.sha256sum] = "e7d481c375a11df55eb8f12390c329c2bfda3258c689cec11cfec27cb5895c8b"
