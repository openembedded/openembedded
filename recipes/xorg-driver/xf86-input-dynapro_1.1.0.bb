require xorg-driver-input.inc
PE = "1"

SRC_URI[archive.md5sum] = "1683178d09dfc604dde9ea2aab950a28"
SRC_URI[archive.sha256sum] = "fc2ad50b1aa027fe57da53cbb73db0b4b9d0de9032f00dd42e7cc0aae7c50d6a"
