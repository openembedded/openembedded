require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- Calcomp input driver"
PE = "1"
SRC_URI[archive.md5sum] = "ebc9a64dc72ae3015c16011bbd2d3557"
SRC_URI[archive.sha256sum] = "bf6edb9d78c90952a16c8bab9e69aebb3e1361e4423ec90e47df57e8c873254b"
