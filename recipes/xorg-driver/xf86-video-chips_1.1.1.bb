require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "3182d43439ca4cbf08ff9aa76990bba3"
SRC_URI[archive.sha256sum] = "16a81cdb6b311176936c3326d279c0d75530adbcf9a3489eea55992ac5bc7494"
