require xorg-driver-input.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " kbproto"

SRC_URI[archive.md5sum] = "06e14029e00b32ed085769775b398efd"
SRC_URI[archive.sha256sum] = "8c45fc324ea01377f9932250824ee1769bdf1eab6e4b661c22a39deb0b01580a"
