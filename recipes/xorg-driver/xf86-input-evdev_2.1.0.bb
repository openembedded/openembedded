require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- evdev input driver"
PE = "1"
SRC_URI[archive.md5sum] = "a6070ead29b2d81b5b386a96df2661b8"
SRC_URI[archive.sha256sum] = "45c4b6df8d1dbc4db8aa580be4f3c693ebba4eba4908d82489948827d3bed0e5"
