require xorg-driver-input.inc
PE = "1"
SRC_URI[archive.md5sum] = "be8a4bd474ad6c85b93f66dd6fcfa6ee"
SRC_URI[archive.sha256sum] = "09b9506d1bb1deaaf69872392bc56e1d75997bb8157e85a9121749bf5fe15727"
