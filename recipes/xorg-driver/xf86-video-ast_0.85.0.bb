require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "b415bf3259ad0acdaf62e3dde76e3289"
SRC_URI[archive.sha256sum] = "9018ff84e4866d895c037aad33fb31c79d5f47d3f54707600cc3fe6076485b28"
