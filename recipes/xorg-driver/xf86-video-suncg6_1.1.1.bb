require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "bc9904a9129aaf73408568ae1e2fa65f"
SRC_URI[archive.sha256sum] = "d1216c7c2be78d1dafad0cd46e464e9fa08f5e04544b76d9a0c547374c85801f"
