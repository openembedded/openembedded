require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- i128 display driver"
PE = "1"
SRC_URI[archive.md5sum] = "aff4922d2f02bad7e0d8649358edbcee"
SRC_URI[archive.sha256sum] = "62eadebd3417ffb3857f10f16597c59541ceb135ddbc30b2140f46d9eb7dddd7"
