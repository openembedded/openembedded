require xorg-driver-video.inc
DESCRIPTION = "X.Org X server -- SiliconMotion display driver"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "9ca392e16028a2f7c3ebc57f0aa4c1aa"
SRC_URI[archive.sha256sum] = "97dd597186029d5646923dde84f4c7f38080ce24c80fd127dcdb8fb36eec7913"
