require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- joystick input driver"
PE = "1"
SRC_URI[archive.md5sum] = "79b20f86d1b2e625ae65e35c3457027f"
SRC_URI[archive.sha256sum] = "718118c5d769529f604c1ff099fe637173442cf01fc40bdef7d45f4baea282a9"
