require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- Calcomp input driver"
PE = "1"
SRC_URI[archive.md5sum] = "689099e2ade8a8c9f68f82fdf569b3ad"
SRC_URI[archive.sha256sum] = "8117b37da2e031eb983e1e98034710a1511299496fcf235f936caff252fa8957"
