require xorg-driver-video.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " xf86dgaproto"
SRC_URI[archive.md5sum] = "c0e8b2f54942b6902b7dd4f30defe800"
SRC_URI[archive.sha256sum] = "d23eb8fa165d238ddf64da63dcd60c70a01cd761608a18402cfb95aed6722495"
