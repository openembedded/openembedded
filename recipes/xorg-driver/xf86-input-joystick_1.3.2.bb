require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- joystick input driver"
PE = "1"
SRC_URI[archive.md5sum] = "e48b99e55093525ebb7811a014391a0b"
SRC_URI[archive.sha256sum] = "6cad238e0a54dec75c5224f9c0774b4fce2a03b06f1c61b404e9ea97d4941d4b"
