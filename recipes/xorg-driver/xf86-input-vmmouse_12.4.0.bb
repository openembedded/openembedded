require xorg-driver-input.inc
PE = "1"

DESCRIPTION = "The VMMouse driver enables support for the special VMMouse protocol \
that is provided by VMware virtual machines to give absolute pointer \
positioning. "

SRC_URI[archive.md5sum] = "313e403e56702f6c38d1a5c830b60dc2"
SRC_URI[archive.sha256sum] = "383e0973aad0e96812fc019cb579abaf016f97427fc07466b150fe15739ba63c"
