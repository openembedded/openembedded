require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "b93e5fe9757db779a75cd3ce97b9613d"
SRC_URI[archive.sha256sum] = "ca25f4c0f706688cbc2dcd03ffaf6a57a17290290257f0cc1b1f1bb261f95b41"
