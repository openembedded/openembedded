require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- evdev input driver"
PE = "1"
SRC_URI[archive.md5sum] = "e56ce4424b89b2409c6e73e007a85da7"
SRC_URI[archive.sha256sum] = "462f2ae2fd389a87e09fa764a236cd04dcbf85bcfcd8000aa9a3810055511d8f"
