require xorg-driver-video.inc

PE = "1"

SRC_URI[archive.md5sum] = "0f7c6be1bbdc5eb43d82b356fe0f5104"
SRC_URI[archive.sha256sum] = "4feb4cd8d239a1b5a944c82b253d106b7f7da083fc4d87a8aeeb822c2e980d8b"
