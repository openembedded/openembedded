require xorg-driver-input.inc
PE = "1"

DESCRIPTION = "X.Org X server -- Tek4957 input driver"
SRC_URI[archive.md5sum] = "8103db1ca5c55726e0b58148e4b1fc06"
SRC_URI[archive.sha256sum] = "b097a5b1acbd732d9ca5d28c13003a1f1c8a3465f4fa77c1578d36330f3358a2"
