require xorg-driver-input.inc
DESCRIPTION = "X.Org X server -- void input driver"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "3056bc7c57db8c5d56039648c0530c45"
SRC_URI[archive.sha256sum] = "aba69784ac83f5951af3e164312adb4b8b1c91a8f79ab35dc5165c534e14c674"
