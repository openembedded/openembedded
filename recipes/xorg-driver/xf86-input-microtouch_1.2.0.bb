require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- MicroTouch input driver"
PE = "1"
