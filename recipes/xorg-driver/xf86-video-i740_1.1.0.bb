require xorg-driver-video.inc

DESCRIPTION = "I740 for X11"

PE = "1"
SRC_URI[archive.md5sum] = "57302e225060a7286ae1a970c87a589b"
SRC_URI[archive.sha256sum] = "b8f2144c987d8a14f8b477ee3aa43fc1c76d040a77e40938c3c97c8e34e2b7c5"
