require xorg-driver-input.inc
PE = "1"

SRC_URI[archive.md5sum] = "43885769d6f741272dda162e82902b0d"
SRC_URI[archive.sha256sum] = "9551f67e24c4573867a64d032d1ff6b63654caab8a85d3c6b2af7748daaa2134"
