require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- Magellan input driver"
PE = "1"
SRC_URI[archive.md5sum] = "8a966d3b74dc2a801ff09b895037090c"
SRC_URI[archive.sha256sum] = "06da7d1b222ba47ba0c7fd561965d78f2c8e46f44c998cb768e98bdc3c0e1741"
