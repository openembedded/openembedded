require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- AceCad input driver"
PE = "1"

SRC_URI[archive.md5sum] = "2c371317f2aae34c04db63c19759a44e"
SRC_URI[archive.sha256sum] = "07d2f8a1153d34a6516b8f1129fc32a18f2862bbb58c9bad4637fb282d60385a"
