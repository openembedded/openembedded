require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- SpaceOrb input driver"
PE = "1"
