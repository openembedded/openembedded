require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "07fa32958aff9b463dd3af5481ef6626"
SRC_URI[archive.sha256sum] = "8ed85a0e94523539d81d5ae6639fa22ceb1c1e3baf89128915db65d4d2900d7a"
