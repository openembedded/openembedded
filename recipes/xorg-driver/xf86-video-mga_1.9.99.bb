require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- MGA display driver"
PE = "1"
SRC_URI[archive.md5sum] = "29785ff1de2b0f7b7f1c48350449447c"
SRC_URI[archive.sha256sum] = "82a91e523d40625c9e042ee640276756d1169cca7eb305c691a3378805c4c81c"
