require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- VMMouse input driver to use with VMWare"
PE = "1"

COMPATIBLE_HOST = 'i.86.*-linux'

SRC_URI[archive.md5sum] = "1c57338928a8897b7ca0b5524fcb1223"
SRC_URI[archive.sha256sum] = "0cb2896b7a284efd6337c019c599fd4d5a6de74a58c6e6c31c31ed399efa8171"
