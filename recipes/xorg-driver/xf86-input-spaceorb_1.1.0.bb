require xorg-driver-input.inc
PE = "1"
SRC_URI[archive.md5sum] = "294810ca9e93c4096458c6a0f2fb5679"
SRC_URI[archive.sha256sum] = "9cd53cb719bf401ff3f72233d3a88c59539b94eaf11e586e307c807a325f0815"
