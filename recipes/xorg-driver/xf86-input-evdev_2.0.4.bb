require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- evdev input driver"
PE = "1"
SRC_URI[archive.md5sum] = "ac97e155ea4db87a8393297493f9c406"
SRC_URI[archive.sha256sum] = "825adcadaf4c90d4cb1d0bd21dcf67bf3b895f12f8e7bf186ed936445dc015ca"
