require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- evdev input driver"
PE = "1"
SRC_URI[archive.md5sum] = "1dbf4d57d99682ba466c7855ed555f19"
SRC_URI[archive.sha256sum] = "8ef48ab7140a70880fa1e6d43b249cdb3e31f1d3c29ca6d39b459672ba16806a"
