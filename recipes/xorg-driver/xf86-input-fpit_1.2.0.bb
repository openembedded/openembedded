require xorg-driver-input.inc
PE = "1"

SRC_URI[archive.md5sum] = "0f3e013d5ff58e0aba3d9e1d18830291"
SRC_URI[archive.sha256sum] = "87e3dd97d57ddb520cafa5e68fa7846cfc3d9d71cb054cdf0e1d650c7b1cff7e"
