require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "ba373233a7d13084d14046a17b02e248"
SRC_URI[archive.sha256sum] = "5becb5f0caf0f99296db28b32be46eb95d0a88ac8e4829c47cb637fb52d06564"
