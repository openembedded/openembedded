require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- AceCad input driver"
PE = "1"

SRC_URI[archive.md5sum] = "51247dc0d73185e35bec326283bc49a5"
SRC_URI[archive.sha256sum] = "48341d8b6b0060228134b36543986c949ea828d6ce6d0484d29b3dde9ddbd556"
