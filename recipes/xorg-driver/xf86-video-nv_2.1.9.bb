require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- NV display driver"
PE = "1"
SRC_URI[archive.md5sum] = "c6b7e52fa18455c22eb040b8d2575ce5"
SRC_URI[archive.sha256sum] = "20d92ff3ab4b9ecc150f4ed17a7012a48f56dbf3fb51b51dde769b28922976d9"
