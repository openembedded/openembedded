require xorg-driver-video.inc
PE = "1"

#DESCRIPTION = ""

#DEPENDS += " "
SRC_URI[archive.md5sum] = "d95ab6445cab477f39adfbbc81006f67"
SRC_URI[archive.sha256sum] = "4a1206cb1a200aad8881216547d9913d0e24928138f3b1bb912a3336b9c05c97"
