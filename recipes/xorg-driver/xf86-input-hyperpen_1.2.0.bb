require xorg-driver-input.inc
PE = "1"

SRC_URI[archive.md5sum] = "175c1e1ad668ebbbe212c1e975dd14f9"
SRC_URI[archive.sha256sum] = "689d1c5c1f21eed00ae03a01c57482f7bbef36d7e07156556c99febe28c7d413"
