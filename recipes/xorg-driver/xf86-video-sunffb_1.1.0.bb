require xorg-driver-video.inc
PE = "1"

DEPENDS += " drm xf86driproto"
SRC_URI[archive.md5sum] = "dee23564c0d8069f52c7cd29c78be667"
SRC_URI[archive.sha256sum] = "f897a427e83cf6965fd82724e3298aea44eb3131ba62f904cb514dfd0a879029"
