require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "b9cb8cfb6a4234bebc434f744af53208"
SRC_URI[archive.sha256sum] = "3564ebc8ccdfea872d46559166d881e93ac7c17e3ed46bb4087960f491c37df9"
