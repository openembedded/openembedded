require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- mouse input driver"
PE = "1"
SRC_URI[archive.md5sum] = "31a51b0e5ddc4fac19754f48a3adf881"
SRC_URI[archive.sha256sum] = "054b253f366795c2865714ce8bc545c79e59aa9ce1b7a9a4a05b9c674dff9dec"
