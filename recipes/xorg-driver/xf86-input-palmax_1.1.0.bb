require xorg-driver-input.inc
PE = "1"

SRC_URI[archive.md5sum] = "0959dbf7972dfb95f56e4bd3f56447cf"
SRC_URI[archive.sha256sum] = "5c00c85eed2950a575362bee2f21c2fa68eb8af81e7f1d451273a1302eac4145"
