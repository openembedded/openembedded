require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "07c9557f6529a88845b01924313e5763"
SRC_URI[archive.sha256sum] = "1528a123b41bf42506eb8e37c3506086395f062cca71f64cbc67929ff1010022"
