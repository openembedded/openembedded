require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X11 driver supporting cards based on the V1000 or the V2x00."

#DEPENDS += " "
SRC_URI[archive.md5sum] = "9a0a916fe1e7b5c81cd4c80a08e646cc"
SRC_URI[archive.sha256sum] = "9d5559fd3029feee5af2493ab8f558c58c426fc89776a1109dab97e3a4764d94"
