require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "This is an unaccelerated driver for the SGI newport cards."

#DEPENDS += " "

SRC_URI[archive.md5sum] = "2bd8e5b9ea68e0dcd80dfcaca0eff82c"
SRC_URI[archive.sha256sum] = "66ac855452690ef896400577806dc1dd86318940f8a62ce20039037318b1ce08"
