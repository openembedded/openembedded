require xorg-driver-input.inc
DESCRIPTION = "X.Org X server -- mouse input driver"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "356b88de59d77fde2936f41239dca89c"
SRC_URI[archive.sha256sum] = "771b82f0d2691e1ae87e712e0532b3667d62663f6f9ed8f56c303a7c64a47492"
