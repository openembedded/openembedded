require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X.Org X server -- S3 ViRGE display driver"
SRC_URI[archive.md5sum] = "6517bbbf808c700502d51acdc44662f8"
SRC_URI[archive.sha256sum] = "1cd00d6e71fdbd70dafe3beb8911d22cbdc5ef7b32d2d81c454ac8a18c967fb8"
