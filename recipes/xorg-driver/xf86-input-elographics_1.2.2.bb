require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- ELOGraphics input driver"
PE = "2"
SRC_URI[archive.md5sum] = "50a9c32af12ca4733afe23042f012f9c"
SRC_URI[archive.sha256sum] = "76ded0e6977f7d562a8236bc810423cd050320531be9621d868a48309ebc4d63"
