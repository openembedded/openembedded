require xorg-driver-video.inc

PE = "1"
DESCRIPTION = "X.Org X server -- SiliconMotion display driver"
SRC_URI[archive.md5sum] = "29fb322cd3adab52cc7f1ac86f9315bb"
SRC_URI[archive.sha256sum] = "ebda468be42695c08ceaa4043da3cf5bcd5f9ab15d1482311fd6e826a8060b2b"
