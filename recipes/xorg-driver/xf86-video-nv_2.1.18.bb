require xorg-driver-video.inc
DESCRIPTION = "X.Org X server -- NV display driver"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "b12f0b2114849d1a542d8084732573d3"
SRC_URI[archive.sha256sum] = "6cf726cc8377cd823ea6038938ea8a88e883fea01b13a749b5491e26535cf415"
