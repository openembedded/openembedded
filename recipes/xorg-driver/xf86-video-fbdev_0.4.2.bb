require xorg-driver-video.inc
DESCRIPTION = "X.Org X server -- fbdev display driver"
PE = "1"
PR = "${INC_PR}.1"

SRC_URI[archive.md5sum] = "53a533d9e0c2da50962282526bace074"
SRC_URI[archive.sha256sum] = "93b271b4b41d7e5ca108849a583b9523e96c51813d046282285355b7001f82d5"
