require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- Glint display driver"

DEPENDS += " xf86dgaproto drm xf86driproto"

SRC_URI[archive.md5sum] = "6d7afdac0a26cf201c3f3b417c31c5e1"
SRC_URI[archive.sha256sum] = "161780d2127d0548a2017ca461ce38e7a69afce5d921a08604e91478c6be1cda"
