require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- NV display driver"
PE = "1"
SRC_URI[archive.md5sum] = "1b22188bd9012a148206940708b52ea6"
SRC_URI[archive.sha256sum] = "c18ce0410437ced9c171d2d6328a8406b79b6edacf55b9526594b446ee5a3641"
