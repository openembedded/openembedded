require xorg-driver-video.inc
DESCRIPTION = "X.Org X server -- dummy display driver"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "1cf99415c998994f2e88575f942b364c"
SRC_URI[archive.sha256sum] = "7e84dff50eb3a783c0bc718a08f82f1f34583531469c98ca75a815d177871bdc"
