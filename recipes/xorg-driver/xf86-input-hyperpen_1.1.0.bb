require xorg-driver-input.inc
PE = "1"

SRC_URI[archive.md5sum] = "1dfccb75069e61e0c6f990b47eb58c40"
SRC_URI[archive.sha256sum] = "d1c20a3340e06c5634759832dcf2edc6acb41476a4f637eba6880730e607f493"
