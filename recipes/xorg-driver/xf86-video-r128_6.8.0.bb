require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- r128 display driver"
PE = "1"
