require xorg-driver-video.inc
DESCRIPTION = "X.Org X server -- SiliconMotion display driver"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "3059e87586e16c34da89437cc6215b49"
SRC_URI[archive.sha256sum] = "b47511480fab5c517e12bd67a332f452d1718b32d53a6201edfc1c279e6e04d7"
