require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- evdev input driver"
PE = "1"
SRC_URI[archive.md5sum] = "bc4b2356e1dbf2d21e1e95249b18f5f8"
SRC_URI[archive.sha256sum] = "dbf3799e207175e91f50492d51343e5cfdc706f637f6e9f14257b764e86bb3f9"
