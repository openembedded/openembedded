require xorg-driver-video.inc
PE = "1"

#DESCRIPTION = ""

#DEPENDS += " "
SRC_URI[archive.md5sum] = "f9b38e24157c3aac6014119ac18d76da"
SRC_URI[archive.sha256sum] = "8d9b5ea137c31919f7821e7f3ecbd133158813c1059f4a8ed0a723535d969952"
