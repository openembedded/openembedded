require xorg-driver-input.inc
PE = "1"

DESCRIPTION = "X.Org X server -- keyboard input driver"

DEPENDS += " kbproto"
