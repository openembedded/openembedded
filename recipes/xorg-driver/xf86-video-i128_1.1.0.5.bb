require xorg-driver-video.inc

DESCRIPTION = "Number Nine I128 for X11"

PE = "1"
