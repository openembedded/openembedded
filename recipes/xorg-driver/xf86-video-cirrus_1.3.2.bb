require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X.Org X server -- Cirrus display driver"
SRC_URI[archive.md5sum] = "8195d03ed0be0975c03441e66a9f53b3"
SRC_URI[archive.sha256sum] = "529a98a42c94ba5e1b9269e6f7b32a9e76cfd2d4728df08aeba615df8b28ca1a"
