require xorg-driver-input.inc
PE = "1"
SRC_URI[archive.md5sum] = "8011f90d7dd801d26e8c3dd058633978"
SRC_URI[archive.sha256sum] = "c5bbade96f1849b45f665a54e08ac8f9d5a94d31a8a680edc4d3c9361d164ac0"
