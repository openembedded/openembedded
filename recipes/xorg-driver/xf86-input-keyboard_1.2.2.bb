require xorg-driver-input.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " kbproto"

SRC_URI[archive.md5sum] = "ab3122921f6359c54e250879288ffd47"
SRC_URI[archive.sha256sum] = "c25b35524eaf00928d97bd0d8bf9e489d92993b133461b5f4d8d9655d37ec072"
