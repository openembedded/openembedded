require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "779a31151e44d2fd2a5ee1794f836889"
SRC_URI[archive.sha256sum] = "72986a3981b746f60df1aba443d610db437fe8d5053e64630686f471c47b01cf"
