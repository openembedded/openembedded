require xorg-driver-input.inc
PE = "1"

SRC_URI[archive.md5sum] = "0d6a81aa864ac790d9a8b517ca7016ad"
SRC_URI[archive.sha256sum] = "8eef54b50c428513a330ed7183ce37f269050252a4d1199d3b00ad6bf0a7833d"
