require xorg-driver-video.inc

PE = "1"
DESCRIPTION = "X.Org X server -- SiliconMotion display driver"
SRC_URI[archive.md5sum] = "a8419a8ed17b02b2a6dd4d30d5e94b00"
SRC_URI[archive.sha256sum] = "cc5301b9c6adb9a0770509b8570d38730d43e9ffce6d6886cd9a090965017e53"
