require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X.Org X server -- S3 ViRGE display driver"
SRC_URI[archive.md5sum] = "4a293047e988d4ea1e9e96d3b5793f43"
SRC_URI[archive.sha256sum] = "9094115621ef73c957cf887332717ec727c751959b1059e3d00fbfe0114a978a"
