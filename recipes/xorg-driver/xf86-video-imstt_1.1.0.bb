require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "94853ca217238ed1f568a10cbeebe057"
SRC_URI[archive.sha256sum] = "9238c2257f9437dd7ab37c049d7f20c010e2f5ff833a37d2d6243f223f10fb7d"
