require xorg-driver-input.inc
DESCRIPTION = "X.Org X server -- mouse input driver"
PE = "1"
PR = "${INC_PR}.1"

SRC_URI[archive.md5sum] = "cef849b1a2743d2e84de98422f372974"
SRC_URI[archive.sha256sum] = "c7ae245e5168276346145f196d1d1faed618f41d5174a2031c71fab6e1a2fbdb"
