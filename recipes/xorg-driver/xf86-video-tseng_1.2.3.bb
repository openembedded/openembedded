require xorg-driver-video.inc
PE = "1"

#DESCRIPTION = ""

#DEPENDS += " "
SRC_URI[archive.md5sum] = "79f63999c88477801ae54dc486272ad6"
SRC_URI[archive.sha256sum] = "0556bb3e79da4be87e880f82e2b8504527e760e284680f9463a08f9572507187"
