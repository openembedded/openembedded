require xorg-driver-input.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "86dbf173283b53c6402618f42adc4441"
SRC_URI[archive.sha256sum] = "43594db310572cfe81383d53934c373638e8be57dc01b34573b4183d0ef1eb9a"
