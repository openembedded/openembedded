require xorg-driver-input.inc
PE = "1"
SRC_URI[archive.md5sum] = "a32e36a24545791a3408cdc5563b6523"
SRC_URI[archive.sha256sum] = "ce41b360bd08ea31036b79cfc25a32c854147522e4580f5ca1a203233e657e1a"
