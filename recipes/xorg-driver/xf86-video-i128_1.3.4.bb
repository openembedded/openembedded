require xorg-driver-video.inc
DESCRIPTION = "X.Org X server -- i128 display driver"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "103316abb2dc466219c027afc5a71691"
SRC_URI[archive.sha256sum] = "b69b13a7fd69f5ad35119b6f8efb3243bfea05ae9aa5a067d0e754de5d248bcf"
