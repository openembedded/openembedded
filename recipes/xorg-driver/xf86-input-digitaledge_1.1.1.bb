require xorg-driver-input.inc
PE = "1"

SRC_URI[archive.md5sum] = "4c27e0f3c6447e76df39a837fd46a00f"
SRC_URI[archive.sha256sum] = "ded010f82b1dbb57b1ee0ad6707902b31540e0592c94d6bbf3b43a7a35220775"
