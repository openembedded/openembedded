require xorg-driver-input.inc
PE = "1"
SRC_URI[archive.md5sum] = "951b2b1a270f67d28e2e89fd2b9f15ae"
SRC_URI[archive.sha256sum] = "3db0e3259034d838c2ff7ae26718422db6d33d89cd1a2defa0efdddbbbfcc28a"
