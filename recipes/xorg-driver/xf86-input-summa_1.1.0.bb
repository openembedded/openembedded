require xorg-driver-input.inc
PE = "1"
SRC_URI[archive.md5sum] = "b37a432fd87bb9f46d011622d6fce6b3"
SRC_URI[archive.sha256sum] = "f10f2cadd4120b40b3658000c87f910e3005f4d787441c7dd83b48ebbf2a11f2"
