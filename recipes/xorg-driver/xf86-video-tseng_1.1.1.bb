require xorg-driver-video.inc
PE = "1"

#DESCRIPTION = ""

#DEPENDS += " "
SRC_URI[archive.md5sum] = "488aa9c3ec7a95e6589afa4b50bec8b4"
SRC_URI[archive.sha256sum] = "c9c1f3318715b7268068bc733d00bcab93924e97eb38f94548e442fd6cdfd56e"
