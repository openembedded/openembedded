require xorg-driver-input.inc
PE = "1"

SRC_URI[archive.md5sum] = "c50d0da3206d18d9d94f720e3688eca5"
SRC_URI[archive.sha256sum] = "e7a13a7597fa32f05d595d05a66cf94c529ba8ce1d03249bb9da5be9512c4b7b"
