require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- wsfb display driver"
PE = "1"
SRC_URI[archive.md5sum] = "d6b5d25dfd61fa5113216d10a6dcbb50"
SRC_URI[archive.sha256sum] = "78bdb6d397869dbd8560ae1f0ee65473977d19ca5afc9fa7638c35057284989e"
