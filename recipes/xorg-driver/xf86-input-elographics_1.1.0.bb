require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- ELOGraphics input driver"
PE = "2"
