require xorg-driver-video.inc
DEPENDS += " drm xf86driproto"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "04c49acb5c5dbde14eabd32d06df6e73"
SRC_URI[archive.sha256sum] = "6b1a00df5c9628817d08f07c6f18f578950744f3eb63b4397be8b0754e728624"
