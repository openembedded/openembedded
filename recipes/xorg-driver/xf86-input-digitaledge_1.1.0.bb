require xorg-driver-input.inc
PE = "1"

SRC_URI[archive.md5sum] = "53461c34cc0712aacab92b820b9fcb84"
SRC_URI[archive.sha256sum] = "24001f19b46b5bc2fcf8212f04863e4efa90175fac797350525e14848ab98a38"
