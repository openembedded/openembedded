require xorg-driver-input.inc
PE = "1"
SRC_URI[archive.md5sum] = "24c33f833bb2db72a07c3d28bfc0aae9"
SRC_URI[archive.sha256sum] = "f1b7f84175d33f4d18c83cd0d37bd3962acd668922fa074a8ae29e18517cdda7"
