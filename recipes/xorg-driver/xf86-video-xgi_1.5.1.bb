require xorg-driver-video.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " xineramaproto xf86miscproto drm xf86driproto"
SRC_URI[archive.md5sum] = "65a8d94d360b51690f8d4b2e7bfa036a"
SRC_URI[archive.sha256sum] = "cb19f5287f9d345fc4fe15ba7c9344a3be2d8395ebf19a139899d1566d7c9e18"
