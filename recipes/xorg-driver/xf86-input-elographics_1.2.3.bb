require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- ELOGraphics input driver"
PE = "2"
SRC_URI[archive.md5sum] = "cc2923460c8eff9652b01889a063058d"
SRC_URI[archive.sha256sum] = "67550c8f4a85a8029f08880adf487e2efd4585e7adbe8da357fbd49750b08d8f"
