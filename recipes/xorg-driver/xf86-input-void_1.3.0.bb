require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- void input driver"
PE = "1"
