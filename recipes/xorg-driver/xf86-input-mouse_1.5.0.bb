require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- mouse input driver"
PE = "1"
SRC_URI[archive.md5sum] = "c58629fddf0782dad5c02da6aeb35521"
SRC_URI[archive.sha256sum] = "f303e20872ab2fb20e07a7f734d17723346d2b4b8687ea2086f7a7468d1ab397"
