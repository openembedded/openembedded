require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- NV display driver"
PE = "1"
SRC_URI[archive.md5sum] = "42f12a36d7afc26c817e8e8f5c8b7274"
SRC_URI[archive.sha256sum] = "f56d2bb42f6c4369dd3c6adc30988c53a229650f910b0db1bb3bf9376054011e"
