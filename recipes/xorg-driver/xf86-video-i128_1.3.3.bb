require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- i128 display driver"
PE = "1"
SRC_URI[archive.md5sum] = "a597e8efeec6ab8bc6ba6d87fceb2dba"
SRC_URI[archive.sha256sum] = "4d0691ce8e3b54075d05cc34717350be42915174b3930b2c9b7f5e309b32b02e"
