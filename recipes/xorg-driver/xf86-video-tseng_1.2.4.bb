require xorg-driver-video.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "fa441774f8bf516a5c6331d64231a39d"
SRC_URI[archive.sha256sum] = "d0dd5dfb4c6a8d0e0baf7fbb5f1784d6b4d1804f1eb188d19963867245e7d13d"
