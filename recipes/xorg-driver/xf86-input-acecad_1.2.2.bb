require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- AceCad input driver"
PE = "1"

SRC_URI[archive.md5sum] = "2d6596b2b0cfa527b5ed4df2014684bf"
SRC_URI[archive.sha256sum] = "953ebb7d7ed579ce648dd6f6a25307c37ad8230a0336ec6fc58247732835f26e"
