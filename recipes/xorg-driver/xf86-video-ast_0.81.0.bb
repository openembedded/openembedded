require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "04bc08907da13612dbc4918fe54e63e3"
SRC_URI[archive.sha256sum] = "b95553aaf89bef28051c82914cee2b91102dbc2370d0d855404ba453902459b8"
