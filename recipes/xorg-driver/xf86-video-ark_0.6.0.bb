require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "6921479baca8f7b156029489fd335854"
SRC_URI[archive.sha256sum] = "e5abc4f4ae643ce56d5773f052515196f05786235e4afd155a3232e20dbc84d7"
