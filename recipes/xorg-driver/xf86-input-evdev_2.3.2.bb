require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- evdev input driver"
PE = "1"
SRC_URI[archive.md5sum] = "b2bfe368022eedf2671ee28daba31efc"
SRC_URI[archive.sha256sum] = "029bf469bd013bcc3e384c1297a05a59e4b9b3ba90a26c022b32c0819d115e28"
