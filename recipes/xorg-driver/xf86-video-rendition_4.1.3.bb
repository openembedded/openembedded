require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X11 driver supporting cards based on the V1000 or the V2x00."

#DEPENDS += " "
SRC_URI[archive.md5sum] = "a8b97feccb32184820d5856fe78d34db"
SRC_URI[archive.sha256sum] = "37e7aef72f7466485f5a3bafd0d43190cb7439de16868bfba2c59bb4c9df4408"
