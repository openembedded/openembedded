require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- void input driver"
PE = "1"
SRC_URI[archive.md5sum] = "862c230f5f6e0c545f232b4c0fa9537a"
SRC_URI[archive.sha256sum] = "dde062d6267a3fd9d51b0daee88fd84fceea52a6019de51dece46e92012dbc4f"
