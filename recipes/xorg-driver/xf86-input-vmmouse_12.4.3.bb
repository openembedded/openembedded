require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- VMMouse input driver to use with VMWare"
PE = "1"
