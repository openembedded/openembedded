require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "559c95f044a31cfe7f71453e9b89c35b"
SRC_URI[archive.sha256sum] = "d71074e941ad8f71ac476651c2ca4142a5c2243e8fecdf216bc0ffbf18338136"
