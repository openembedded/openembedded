require xorg-driver-input.inc
PE = "1"
SRC_URI[archive.md5sum] = "af13f9de2af4e1d03b2da0c037fd718a"
SRC_URI[archive.sha256sum] = "ebc446e74eea72d391104b1ce3b2a5376bced098154ec089a944f4311d240904"
