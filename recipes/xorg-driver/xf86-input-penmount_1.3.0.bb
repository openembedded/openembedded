require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- Penmount input driver"
PE = "1"
SRC_URI[archive.md5sum] = "24594c0222e631fedccc7c540c420b03"
SRC_URI[archive.sha256sum] = "9cb4e0e83dcefe1ece814d638bd186785b6bc1debe1aa2101ce2a4ea0376805a"
