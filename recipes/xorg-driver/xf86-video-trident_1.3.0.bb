require xorg-driver-video.inc

DESCRIPTION = "X.org X server -- Trident display driver"
DEPENDS += " xf86dgaproto"
PE = "1"
SRC_URI[archive.md5sum] = "e89799579d0cf3858362bd751469e0bf"
SRC_URI[archive.sha256sum] = "a4f66c9f46f6e93c2c1f10e782a211ddc338b0ff9f0a2ccd2d660db031d3ddb5"
