require xorg-driver-video.inc

PE = "1"

DESCRIPTION = "Video 4 Linux adaptor driver for X11"
SRC_URI[archive.md5sum] = "2251ae2a0a905764941cd7b098e85ad1"
SRC_URI[archive.sha256sum] = "cbff9120fbad900cbdc7ac535d04984e7b491d69a8eb0b371e30ae07cb61925d"
