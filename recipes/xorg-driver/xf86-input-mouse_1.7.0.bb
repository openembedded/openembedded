require xorg-driver-input.inc
DESCRIPTION = "X.Org X server -- mouse input driver"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "7f31472689c15b6de62eff04d0fb57d7"
SRC_URI[archive.sha256sum] = "4e989542b5e9e0c5f9087288b18e70de1064dd27c83a4bc6dce58f3ea9d74994"
