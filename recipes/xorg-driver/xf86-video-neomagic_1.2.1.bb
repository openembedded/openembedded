require xorg-driver-video.inc

PE = "1"

DESCRIPTION = "X11 driver for NeoMagic 2200, 2160, 2097, 2093, 2090, 2070"

DEPENDS += " xf86dgaproto"

SRC_URI[archive.md5sum] = "a72f57fca4f4dff9a2c82eb1fe7456f4"
SRC_URI[archive.sha256sum] = "96e38d5378596174f76c735c4723ff2ac336f9069644502a9b706586b845e0a5"
