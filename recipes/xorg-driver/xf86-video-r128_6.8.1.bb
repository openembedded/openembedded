require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- r128 display driver"
PE = "1"
SRC_URI[archive.md5sum] = "2b90854a62a4d45d652062f582dc8d13"
SRC_URI[archive.sha256sum] = "517e21cc83850b903549d698c9daeb633e8b9ba5b187fe298409cc51975a9eca"
