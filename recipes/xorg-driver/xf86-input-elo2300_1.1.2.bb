require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- ELO2300 input driver"
PE = "1"

SRC_URI[archive.md5sum] = "611d0a77a80286bc926dd3c414e59555"
SRC_URI[archive.sha256sum] = "ce575f79a5a93f4129a4e63572911d54cdc6640abc303afeb3c74741bb3c9627"
