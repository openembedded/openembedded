require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X.Org X server -- fbdev display driver"

#DEPENDS += " "
SRC_URI[archive.md5sum] = "79ce1eb9f9d2ed56de70d8e06cb767d9"
SRC_URI[archive.sha256sum] = "2bf857179523433a9cc6c6eea059298db4c865e649aa58dfc67c828f28b7288f"
