require xorg-driver-input.inc
PE = "1"

DESCRIPTION = "Mouse Support in X11"

#DEPENDS += " "

SRC_URI[archive.md5sum] = "72b07e65bbea6ab484d84c048f6835fb"
SRC_URI[archive.sha256sum] = "82671998e2b02ad097e3d5cc7d964e11de0b3ca3dfec4876e8fa2a13af6aacc3"
