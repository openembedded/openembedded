require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- ELO2300 input driver"
PE = "1"

