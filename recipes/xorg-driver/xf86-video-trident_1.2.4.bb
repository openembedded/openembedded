require xorg-driver-video.inc

DESCRIPTION = "X.org X server -- Trident display driver"
DEPENDS += " xf86dgaproto"
PE = "1"
SRC_URI[archive.md5sum] = "7f628f7eb4abdc4c49bb252eefc4335a"
SRC_URI[archive.sha256sum] = "f942596e7427a089be9c9353c45c22002999580197c9715d9363d19ee170ba8d"
