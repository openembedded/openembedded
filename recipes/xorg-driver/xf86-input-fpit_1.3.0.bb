require xorg-driver-input.inc
PE = "1"

SRC_URI[archive.md5sum] = "e5bfda480f25121e3c4222e5e1eb5880"
SRC_URI[archive.sha256sum] = "d1ced3b8c6d799c3af1c93e72dc571cb30d38083e1221b8ea0b2d4fc48a7eef8"
