require xorg-driver-input.inc
DESCRIPTION = "X.Org X server -- evdev input driver"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "e84a4d2338638669fb994ec3653266c3"
SRC_URI[archive.sha256sum] = "def9a3edd986e341bccf57ee992c6af4453b06c47e13710600106d83d80660f2"
