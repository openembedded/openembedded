require xorg-driver-video.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " xineramaproto xf86miscproto drm xf86driproto"
SRC_URI[archive.md5sum] = "0e7d0df07528c57304900da3acafc1a2"
SRC_URI[archive.sha256sum] = "ee0a178c89ff10d679e6f174d2a2e5cc7b89c7c7d5c115d48e9c75942f487395"
