require xorg-driver-video.inc

PE = "1"

DESCRIPTION = "X11 driver for NeoMagic 2200, 2160, 2097, 2093, 2090, 2070"

DEPENDS += " xf86dgaproto"

SRC_URI[archive.md5sum] = "7a3d3d6e60b9686d955c45d9ebbd5c1b"
SRC_URI[archive.sha256sum] = "d6497080967b8285b663fedd7cafd4457578282ebd7da0b216b6fa214dd88a86"
