require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "b064a8d2f3d481ec36ef9ac17e13a77d"
SRC_URI[archive.sha256sum] = "543115c4b3a8603dcc9d7a3030c9e7ce20baf6e3976d92ff951cfea80b54981e"
