require xorg-driver-video.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " drm xf86driproto"
SRC_URI[archive.md5sum] = "9c5e541613b07de6e7b2b2df3a2e35b1"
SRC_URI[archive.sha256sum] = "f5f154df377cb445935d1453d6b7095d63912d5776dcb44f8d3c2f10ab1a3cc5"
