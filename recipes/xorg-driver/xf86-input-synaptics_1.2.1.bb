require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- mouse input driver"
PE = "1"
SRC_URI[archive.md5sum] = "29a6f9da5123149e4abc8ff83880ed5c"
SRC_URI[archive.sha256sum] = "a63b48c5c8eb09416b941dea591a948e111d1b2e14d4620f25377cf47cf877e6"
