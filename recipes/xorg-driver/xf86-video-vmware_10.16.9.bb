require xorg-driver-video.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " xineramaproto xf86miscproto drm xf86driproto"
SRC_URI[archive.md5sum] = "3b3d38abfa1f8be4b1e26dcd236bc94f"
SRC_URI[archive.sha256sum] = "835a5e45b54837cbbd963a48bd09db709717e097e931dd76e68e397a167e8bc1"
