require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "11066b84b949cd04300ec819c9c51532"
SRC_URI[archive.sha256sum] = "d57dd2323052f064092167a232fb7576f46e5d62e98bc9cc6a7f270cc8d0fdc0"
