require xorg-driver-video.inc
DESCRIPTION = "X.Org X server -- ark display driver"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "ff0cb9cb0a7f36cc6f556deed7327798"
SRC_URI[archive.sha256sum] = "39149a565c64ae013962022c45e561a0e92c5ab413688f3b5055cad694f28f98"
