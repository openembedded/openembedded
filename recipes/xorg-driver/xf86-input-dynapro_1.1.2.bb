require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- Dynapro input driver"
PE = "1"

SRC_URI[archive.md5sum] = "ceb5efbd3d62e24ab3a5f9f180777f7c"
SRC_URI[archive.sha256sum] = "55b7b2e950331292ec05c81d566af6d1000ac3cf904068964c3b9d43cea4deec"
