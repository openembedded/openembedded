require xorg-driver-video.inc
DESCRIPTION = "X11 driver supporting cards based on the V1000 or the V2x00."
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "75cc28125077acb7344955294545553b"
SRC_URI[archive.sha256sum] = "3b9b8e6709c3a7c00904e9a6cb63d7805b5f5f33dc96254f438c1f8d5fb72aa9"
