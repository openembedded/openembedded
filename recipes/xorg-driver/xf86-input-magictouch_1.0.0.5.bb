require xorg-driver-input.inc
PE = "1"

SRC_URI[archive.md5sum] = "d23f2791cd634ef85b7cc5e9da8f8407"
SRC_URI[archive.sha256sum] = "9cedc831e9d86889f473fbe3b8f1478afe5ed8c0dd71492aeb896cc681d7444c"
