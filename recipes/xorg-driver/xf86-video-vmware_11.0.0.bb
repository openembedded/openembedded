require xorg-driver-video.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " xineramaproto xf86miscproto drm xf86driproto"
SRC_URI[archive.md5sum] = "2895deafa373b0f87b8a7feaf0ca2373"
SRC_URI[archive.sha256sum] = "bb538ebb9f000767bcc389562c8deb4cda74aa3e608190f6c3ee1e93d394fb2d"
