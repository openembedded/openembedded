require xorg-driver-video.inc
DESCRIPTION = "This is an unaccelerated driver for the SGI newport cards."
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "923baa1ee0429f03ed19ec0be6a4f62b"
SRC_URI[archive.sha256sum] = "e6caeb4f95adfd9d2046d24f5f3688092ea4e3fb63aa3d0675f6c697c8cf0270"
