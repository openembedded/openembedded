require xorg-driver-input.inc

DESCRIPTION = "X.Org X Server -- Citron input driver"
PE = "1"

