require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "a2b9c70a32b0a6436d837d67fa7aae18"
SRC_URI[archive.sha256sum] = "f0b68171dd4256c927fbee91ecf84fa28c409b5b6b39cbf47eaa48fd73db305f"
