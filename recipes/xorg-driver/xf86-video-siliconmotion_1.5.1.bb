require xorg-driver-video.inc

PE = "1"
#DESCRIPTION = ""

#DEPENDS += " "
SRC_URI[archive.md5sum] = "ee35d7714ce44a2b5ac7ad7b7b7dd75a"
SRC_URI[archive.sha256sum] = "54cf791695a53d4836d32f899b7d34b969edf5415f02e36956b6e72993e21cd7"
