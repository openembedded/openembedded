require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "9e25784e912cb2f0493b87431fd60773"
SRC_URI[archive.sha256sum] = "1eca2b0970e725db49f9e462a0c2e618b2616389647335b5aec9d6e495e40527"
