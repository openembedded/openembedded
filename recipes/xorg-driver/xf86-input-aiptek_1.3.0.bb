require xorg-driver-input.inc
PE = "1"
SRC_URI[archive.md5sum] = "ae3ec07aff6c156cf5307f53feb6b293"
SRC_URI[archive.sha256sum] = "b37f35bb021dffc337c731bfbbb6ce7c0953dc69f7c660cbe48b0f84a07b5e5c"
