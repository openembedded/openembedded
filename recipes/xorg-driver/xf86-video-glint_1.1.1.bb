require xorg-driver-video.inc

#DESCRIPTION = ""

DEPENDS += " xf86dgaproto drm xf86driproto"
SRC_URI[archive.md5sum] = "2cf49f701024a145bd25aff9da11d479"
SRC_URI[archive.sha256sum] = "d63e0dd3f5cecebaf1915193a68ac83e90c1e973e3276a71bd14651d67115e6d"
