require xorg-driver-video.inc
PE = "1"

#DESCRIPTION = ""

#DEPENDS += " "
SRC_URI[archive.md5sum] = "e4dc415b1e45db0bbdacc203ed33024a"
SRC_URI[archive.sha256sum] = "97d47df7720d3cfcb56c4debca9218c3fc5352d34d82bc4880c8a620185f8c5e"
