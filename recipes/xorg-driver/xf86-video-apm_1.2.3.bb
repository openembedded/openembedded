require xorg-driver-video.inc
DESCRIPTION = "This is the Alliance Promotion driver for XFree86 4.0+"
DEPENDS += " xf86rushproto"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "a3743a971b3acb7de3d2eefc8b1a4834"
SRC_URI[archive.sha256sum] = "4046ea18dbd76a9df5f68695025c2c411c20564af9198974506a041ebd4a30da"
