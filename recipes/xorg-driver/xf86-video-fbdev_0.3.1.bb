require xorg-driver-video.inc
PE = "1"

#DESCRIPTION = ""

#DEPENDS += " "
SRC_URI[archive.md5sum] = "9ae810c6c6c3c9713a67866fe794d4ff"
SRC_URI[archive.sha256sum] = "309d1f618c77559ea494c05d45b09577790c44900685e17bc812e4e1b19df6e7"
