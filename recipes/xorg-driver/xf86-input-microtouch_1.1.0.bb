require xorg-driver-input.inc
PE = "1"
SRC_URI[archive.md5sum] = "7b3cc0330d70e7e4e07914fcb325b331"
SRC_URI[archive.sha256sum] = "7f92f5531495ecfbfd00744198fd4b2aa3b8f5c188b115e55e865e961bca2039"
