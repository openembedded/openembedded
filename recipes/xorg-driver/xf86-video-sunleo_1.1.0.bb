require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "0408d95795d754c92d12d6476b6932a1"
SRC_URI[archive.sha256sum] = "b504d50f261bea9bc9dcd2a9c9c3307b24dee97c18d13b5a6deb3eb393270da9"
