require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- DMC input driver"
PE = "1"

SRC_URI[archive.md5sum] = "f21f008220bc7687ce1c34ab557ec32f"
SRC_URI[archive.sha256sum] = "f98c5a7010fa71cee88b4c2470e5cd804e42dfbc5292cf1c20eb75e9b1814002"
