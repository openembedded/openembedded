require xorg-driver-input.inc
PE = "1"

DESCRIPTION = "X.Org X server -- muTouch input driver"
SRC_URI[archive.md5sum] = "50711d390d2867e3fa7e06b59b2d575b"
SRC_URI[archive.sha256sum] = "214f0831f36ebfc081b9f31f91ae27972ced9371b9b2256650998596a097061d"
