require xorg-driver-video.inc
PE = "1"
SRC_URI[archive.md5sum] = "1bb374fe5ab3ed780d353b2b12ba6255"
SRC_URI[archive.sha256sum] = "fd377af6e366e8e3a77c8ff825a009138c8343c0007bbf070ad605a649577e11"
