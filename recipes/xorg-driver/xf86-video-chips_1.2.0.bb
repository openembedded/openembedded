require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X.Org X server -- Chips display driver"
SRC_URI[archive.md5sum] = "0fec6bee65383790485d917247a61629"
SRC_URI[archive.sha256sum] = "05f38c49b23be36afa68b738faf520b8dbf05b92c769107039426651801d4f99"
