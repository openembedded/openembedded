require xorg-driver-video.inc
PE = "1"

DESCRIPTION = "X.Org X server -- Cirrus display driver"
SRC_URI[archive.md5sum] = "bc28fdedaee9059180e2534f9dbcd2f6"
SRC_URI[archive.sha256sum] = "e7c99ed66326df5fadf6e5d875859a430fec4369415a27cde72a91109f78bb9c"
