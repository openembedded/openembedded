require xorg-driver-input.inc
PE = "1"

SRC_URI[archive.md5sum] = "ea72a92d43b95f413347df96d6a73933"
SRC_URI[archive.sha256sum] = "b43c5d920821bd06b6a1a131dd071ab838bf024c3cb092c6d1f10d57b648b0e4"
