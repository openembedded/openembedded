require xorg-driver-input.inc
PE = "1"
SRC_URI[archive.md5sum] = "2aa75313ea5652a8cf93581c65ee6493"
SRC_URI[archive.sha256sum] = "219116b0275b93333b8471fc94d97320a116d695c4249837fd97763f00a85d77"
