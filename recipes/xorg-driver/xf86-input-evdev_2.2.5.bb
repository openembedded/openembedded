require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- evdev input driver"
PE = "1"
SRC_URI[archive.md5sum] = "e926692d74ee81ed459d0fe89439ff8b"
SRC_URI[archive.sha256sum] = "433fd29043cd427ba486bcce471aae3ad1abca94c8682feff92da0c380b8dff3"
