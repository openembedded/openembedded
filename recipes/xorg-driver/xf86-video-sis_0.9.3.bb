require xorg-driver-video.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " xineramaproto xf86miscproto xf86dgaproto drm xf86driproto"

SRC_URI[archive.md5sum] = "e35d817fa4ee7beb6cd5aa744b9c0783"
SRC_URI[archive.sha256sum] = "898ee8fb16fff89ba8ac5c83b9f5a2371084719db0cf034140427229191436f6"
