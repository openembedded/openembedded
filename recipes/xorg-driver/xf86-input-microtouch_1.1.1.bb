require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- MicroTouch input driver"
PE = "1"
SRC_URI[archive.md5sum] = "9843fbea6cc0c4129e96ce9a6c893cf6"
SRC_URI[archive.sha256sum] = "5f2f0b16705c6226081a452f9f876508c388b384fca69106d377cd134cfddfd3"
