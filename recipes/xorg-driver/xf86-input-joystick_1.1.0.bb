require xorg-driver-input.inc
PE = "1"

SRC_URI[archive.md5sum] = "e0025215542c7a11c5a7f9548631dbd7"
SRC_URI[archive.sha256sum] = "11c3e8056e8f44b9a6f348b5366c7e725155563374770b82e339e913b9a60d16"
