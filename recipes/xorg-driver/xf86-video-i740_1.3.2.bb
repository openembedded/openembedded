require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- i740 display driver"

PE = "1"
SRC_URI[archive.md5sum] = "4ac1318788f62159965f15131c869e7a"
SRC_URI[archive.sha256sum] = "48549c6a3d8c0a0d417fc486e77f3f7c6815df7e8ede04bb4c539666be2bf943"
