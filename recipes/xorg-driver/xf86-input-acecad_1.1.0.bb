require xorg-driver-input.inc
PE = "1"

SRC_URI[archive.md5sum] = "ce0b7bec500273ad935cbfa212b8ac8a"
SRC_URI[archive.sha256sum] = "3e5feea79f1d48cd46a2a40661140042ac586f90311669f79d65fea6cfc112ad"
