require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- NV display driver"
PE = "1"
SRC_URI[archive.md5sum] = "192414222f1a98e228832ee53f8178c0"
SRC_URI[archive.sha256sum] = "7c9135d80b519246b2a85ff0481d6ee0fddeb578d669ff490f236f85873e8c5a"
