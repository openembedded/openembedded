require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- Dynapro input driver"
PE = "1"

