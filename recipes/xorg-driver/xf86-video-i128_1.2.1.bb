require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- i128 display driver"
PE = "1"
SRC_URI[archive.md5sum] = "d0080732eaa15059b0a953aa3522185a"
SRC_URI[archive.sha256sum] = "0d023cacf8134241cd8efcd5744eb156399406c92f59d3895392f2b5fd055eb1"
