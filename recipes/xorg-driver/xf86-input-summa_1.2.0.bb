require xorg-driver-input.inc
PE = "1"

DESCRIPTION = "X.Org X server -- Summa input driver"
