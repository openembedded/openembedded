require xorg-driver-input.inc
PE = "1"

#DESCRIPTION = ""

#DEPENDS += " "

SRC_URI[archive.md5sum] = "0589f2eaa84afb9bd49b226ce7dacdda"
SRC_URI[archive.sha256sum] = "dea18a07cf8f59e7bc981cfa1f6ef476dd14f7d9bee3bb1a55a6cc49f766150e"
