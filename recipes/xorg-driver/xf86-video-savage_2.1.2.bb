require xorg-driver-video.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " drm xf86driproto"
SRC_URI[archive.md5sum] = "6367e921a98f6a7fec9d0a9bc5ff0a47"
SRC_URI[archive.sha256sum] = "1a9aa442152c139e3c54bc6c323bd13edf0bfff70a81c03969bcb1159317edb2"
