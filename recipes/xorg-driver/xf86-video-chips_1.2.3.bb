require xorg-driver-video.inc
DESCRIPTION = "X.Org X server -- Chips display driver"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "e3e8b8661b3ba2159f83f64e2aa6e29f"
SRC_URI[archive.sha256sum] = "0561278e06f84d4ee20317b19831cc8d42c952a1577c7865163ad2d6d900cb1d"
