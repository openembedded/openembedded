require xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- NV display driver"
PE = "1"
SRC_URI[archive.md5sum] = "fb02d5506e35054348d1c2b2c924530d"
SRC_URI[archive.sha256sum] = "4bf2f964b78d309769faa6a5d21c90a9907886623adf1f30ea890b4329bf578d"
