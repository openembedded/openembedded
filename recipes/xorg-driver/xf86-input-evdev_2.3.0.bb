require xorg-driver-input.inc

DESCRIPTION = "X.Org X server -- evdev input driver"
PE = "1"

DEFAULT_PREFERENCE = "-1"
DEFAULT_PREFERENCE_shr = "1"
