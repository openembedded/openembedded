require xorg-driver-video.inc

DESCRIPTION = "X.org X server -- Trident display driver"
DEPENDS += " xf86dgaproto"
PE = "1"
SRC_URI[archive.md5sum] = "47f3c5da1942017218355f178f02ef84"
SRC_URI[archive.sha256sum] = "6241eab6f3f0a075380be6b614e33ad72256242c865115bc8b696f83a75d11f5"
