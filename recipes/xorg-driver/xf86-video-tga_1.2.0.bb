require xorg-driver-video.inc

PE = "1"

DESCRIPTION = "DEC 21030 X11 driver"

DEPENDS += " xf86dgaproto"

