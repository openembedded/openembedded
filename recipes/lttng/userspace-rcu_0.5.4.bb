require ${PN}.inc
SRC_URI[md5sum] = "04147d24749be75200173859839207f7"
SRC_URI[sha256sum] = "02aedbb16c16bd034e246d5c9637a9232be559c66fc2fe4eb28948e234bd89f1"
