require ${PN}.inc
SRC_URI[md5sum] = "333ff7c8fef92b31dff85789865bb791"
SRC_URI[sha256sum] = "802398bc2c3ad5c80bd236d1ee24968f4da8a1401695e8dc15cb396ac836abb4"
