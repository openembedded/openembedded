require libopensync-plugin_0.36.inc

SRC_URI[md5sum] = "785a79d70e3d6e0637c7f21b2a09987c"
SRC_URI[sha256sum] = "932726d69b398686b9d6a1e2afd53c537c03ae8a476df1b8b00ba1f8b4abbf44"
