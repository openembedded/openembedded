require libopensync-plugin_0.36.inc

DEPENDS += " check"

SRC_URI[md5sum] = "f3d1efdc1e7142fc74364e92f2066ee0"
SRC_URI[sha256sum] = "926e6125b4be2d206c6618f8e9445a465df44fe013f23ec339679af307b342c9"
