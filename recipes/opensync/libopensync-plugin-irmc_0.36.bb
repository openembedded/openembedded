require libopensync-plugin_0.36.inc

DEPENDS += "openobex bluez-libs"

SRC_URI[md5sum] = "21f9789fa41c2f06c547a17bc13c6081"
SRC_URI[sha256sum] = "f7ccff0bc136d3aa21ab961f31414f4856a94e9f1a1b17c44c8ec33b67ace4ac"
