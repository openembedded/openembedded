require libopensync-plugin.inc
require libopensync-plugin_0.22.inc

DEPENDS += "openobex bluez-libs"

SRC_URI[md5sum] = "ecec872b2bccd824b1c5cbb2ec1d5399"
SRC_URI[sha256sum] = "4bed935f596bd5ae11f6263a97e3cd25029a911f7e476e9b8f11b8036d89a0f6"
