require libopensync-plugin_0.36.inc

DEPENDS += " eds-dbus"

SRC_URI[md5sum] = "ed3aca114a81ad8cc543b3dd68af657a"
SRC_URI[sha256sum] = "19f1a24d54daec7b6e1321548799e500893b8aebe6dda995dc8eb162f77932c2"
