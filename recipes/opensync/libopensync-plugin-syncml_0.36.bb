require libopensync-plugin_0.36.inc

DEPENDS += " libsyncml (>= 0.4.6)"

SRC_URI[md5sum] = "3c83493143fbfabf6600aea8d310167c"
SRC_URI[sha256sum] = "d0db5ccdbf98012a9b70671c7b90cf8eed1f5133ac61563e97d7abf1533dc6e9"
