require libopensync-plugin.inc
require libopensync-plugin_0.22.inc

SRC_URI[md5sum] = "d600836ab5182751d07ea42c6b997eb4"
SRC_URI[sha256sum] = "52231306a388f7ad49b273e0a90e3320811cfcad6c222669d05fe92e4c157825"
