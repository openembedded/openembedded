require libopensync-plugin_0.36.inc

SRC_URI[md5sum] = "69b382845fb62a58e1976bc74a82dd86"
SRC_URI[sha256sum] = "df3b64322b5f7e0e67317e58b46e9884837a771c69d9513dfb16dafeaeaaa2bb"
