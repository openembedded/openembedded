PLUGIN_NAME = "evolution2"

require libopensync-plugin.inc
require libopensync-plugin_0.22.inc

DEPENDS += " eds-dbus"

SRC_URI[md5sum] = "c4419dd2451bd1595fe42fcf96a9ba45"
SRC_URI[sha256sum] = "2a309178a1aafaa147b792502a241e0036889e2f4153065a10313e7db3c26e65"
