require xorg-data-common.inc

DESCRIPTION = "Common X11 Bitmaps"
LICENSE = "MIT"
DEPENDS += "libxmu"


SRC_URI[archive.md5sum] = "b28a9840cde3c38d7c09716372fea257"
SRC_URI[archive.sha256sum] = "5aa5be594e77f772b85d39f0c25f61a61c7f6fa02ba940e614c5ee386deeb867"
