require xorg-data-common.inc

DESCRIPTION = "Common X11 Bitmaps"
LICENSE = "MIT"
DEPENDS += "libxmu"


SRC_URI[archive.md5sum] = "f9ddd4e70a5375508b3acaf17be0d0ab"
SRC_URI[archive.sha256sum] = "c9a2059c8b0636b7ee1169647bb22f6eb4a0589e36fdb98936002e2569ad8761"
