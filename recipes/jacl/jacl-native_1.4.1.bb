require jacl_${PV}.bb

inherit java-native

