require pango.inc

PR = "${INC_PR}.1"

SRC_URI += "file://CVE-2010-0421.patch;patch=1"


SRC_URI[archive.md5sum] = "f2eeaf183930e00ed28fca3a6ed1deb0"
SRC_URI[archive.sha256sum] = "adbd11f182ec63939d6364cbb59e86991a48582e7d3641cda80529b40b399559"
