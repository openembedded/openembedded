require pango.inc

SRC_URI += "file://pkgconfig_fixes.patch;patch=1"

