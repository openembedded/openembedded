require pango.inc
PR = "r2"



SRC_URI[archive.md5sum] = "37a185a3cb5c1a39ade7fdc3e6c75349"
SRC_URI[archive.sha256sum] = "75fa65f965c8b9b80b1a0a270ad5dfbe71eaa980451790a0c86fdd19f55cd150"
