require pango.inc


SRC_URI[archive.md5sum] = "025e2ac5e40cac163aae4653aeef559c"
SRC_URI[archive.sha256sum] = "1bdef802f138fabdaea10b97a4a86060a4aac63db970ea3aa1df697b33954ffc"
