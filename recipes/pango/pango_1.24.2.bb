require pango.inc

