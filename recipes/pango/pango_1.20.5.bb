require pango.inc


SRC_URI[archive.md5sum] = "052b60a12f6b2eb4f251ab961f2b2b84"
SRC_URI[archive.sha256sum] = "86f5a94bad18a24c32d6c95f4aad0de643189471825d07e1c1bcaf7cc5a8fab2"
