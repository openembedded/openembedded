PR = "r1"

TOOLCHAIN_TARGET_TASK = "task-shr-toolchain-target"
TOOLCHAIN_HOST_TASK = "task-shr-toolchain-host"

require meta-toolchain.bb
SDK_SUFFIX = "toolchain-shr"
