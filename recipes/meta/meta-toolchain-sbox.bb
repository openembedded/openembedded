PR = "r1"
TOOLCHAIN_TARGET_TASK = "\
    task-sdk-bare \
    task-sdk-sbox"

require meta-toolchain.bb

SDK_SUFFIX = "toolchain-sbox"

