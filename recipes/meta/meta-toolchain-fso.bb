PR = "r0"

TOOLCHAIN_TARGET_TASK = "task-fso-toolchain-target"
TOOLCHAIN_HOST_TASK = "task-fso-toolchain-host"

require meta-toolchain.bb
SDK_SUFFIX = "toolchain-fso"
