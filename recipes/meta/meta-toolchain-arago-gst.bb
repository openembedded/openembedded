TOOLCHAIN_HOST_TASK = "task-arago-toolchain-gst-host"
TOOLCHAIN_TARGET_TASK = "task-arago-toolchain-gst-target"

require meta-toolchain-arago-dvsdk.bb

PR = "r13"

SDK_SUFFIX = "gst-sdk"
