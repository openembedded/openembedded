DESCRIPTION = "Meta-package for SDL"
LICENSE = "MIT"
PR = "r3"

RDEPENDS_${PN} = "task-sdl-libs task-sdl-games task-sdl-emulators"

inherit meta
