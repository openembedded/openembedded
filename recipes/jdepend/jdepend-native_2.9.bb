require jdepend_${PV}.bb

inherit java-native

