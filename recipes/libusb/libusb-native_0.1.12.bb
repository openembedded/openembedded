require libusb_${PV}.bb
inherit native
PROVIDES = "virtual/libusb0-native"
