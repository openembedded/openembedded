require ${PN}.inc

SRC_URI[md5sum] = "4efcf3945b17a6f0320cf1aaa326a4de"
SRC_URI[sha256sum] = "dc000523df508e457ead6447b2d9a2c549fbff525783c13a96d19bbd61137b88"
