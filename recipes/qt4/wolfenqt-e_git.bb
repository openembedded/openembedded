WOLFVARIANT = "e"
require wolfenqt.inc



