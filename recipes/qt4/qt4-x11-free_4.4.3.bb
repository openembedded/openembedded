require qt4-x11-free.inc
PR = "r6"

