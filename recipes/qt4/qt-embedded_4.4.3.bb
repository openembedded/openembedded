require qt-embedded.inc
PR = "r7"
