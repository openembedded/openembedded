require qt4-tools-native.inc
PR = "r0"

DEFAULT_PREFERENCE = "-1"
TOBUILD := "src/tools/bootstrap ${TOBUILD}"
