require qt4-tools-native.inc

DEFAULT_PREFERENCE = "-1"
TOBUILD := "src/tools/bootstrap ${TOBUILD}"
