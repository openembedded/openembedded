require recipes/uhd/uhd-firmware.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "00bf346a4e6b8fb1f0d1633e4464cd34"
SRC_URI[sha256sum] = "231e8e63b6a3348b36881540e3738912d082a74118fd439feeec32ed76b56ba3"

