require recipes/uhd/uhd-firmware.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "1894391da027884e5eed474606250be9"
SRC_URI[sha256sum] = "c194d9e30bb02225de623400bdba9be9200f70a57c6220506bc0b051eed8fae8"

