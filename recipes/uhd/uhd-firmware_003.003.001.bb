require recipes/uhd/uhd-firmware.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "84ec78ec03699a96d64210b93019f782"
SRC_URI[sha256sum] = "53712db43b324adad1b83617f99f7b73682bcd0078bbc9915d0a376f4ca41289"

