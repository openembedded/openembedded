require recipes/uhd/uhd-firmware.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "0d6a6792c6b98e9163d67cb62bf29dce"
SRC_URI[sha256sum] = "3b25726946026c6d25061403e3343d72b34cc41e7e44026b272510379d01233a"

