require coreutils-${PV}.inc
require coreutils-native.inc

PR = "r4"

SRC_URI[md5sum] = "c15219721e6590fa13bf50af49e712c2"
SRC_URI[sha256sum] = "efa27532ec6dc12a21f703ad4a0f612e613e9cc2575147685db81cc701952ac9"
