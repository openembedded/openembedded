require coreutils-${PV}.inc
require coreutils-target.inc

PR = "r0"
