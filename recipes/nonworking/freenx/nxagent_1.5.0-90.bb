SRC_URI = "http://64.34.161.181/download/1.5.0/sources/${P}.tar.gz"
inherit autotools
S = "${WORKDIR}/${PN}"
SRC_URI[md5sum] = "b4565a78114114dae6f7be46b6a4f3da"
SRC_URI[sha256sum] = "e4d28b32f41f123a57145a964356569ef75a04fe1193f3f30caef8f1b3b8f7e5"
