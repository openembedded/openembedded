SRC_URI = "http://64.34.161.181/download/1.5.0/sources/${P}.tar.gz"
inherit autotools
S = "${WORKDIR}/${PN}"
SRC_URI[md5sum] = "b5a9e3769890af7150ffec13689e1e83"
SRC_URI[sha256sum] = "b374038154abc9f708363043ef73dcb1537bd21a7441aed0183734519956bf45"
