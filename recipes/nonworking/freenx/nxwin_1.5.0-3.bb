SRC_URI = "http://64.34.161.181/download/1.5.0/sources/${P}.tar.gz"
inherit autotools
S = "${WORKDIR}/${PN}"
SRC_URI[md5sum] = "8e515372dd4a112c5a95eafb70227cd9"
SRC_URI[sha256sum] = "7923d226123b3ee57733654fa53132ee9825c420ae89dabbff97374cac5c81a8"
