SRC_URI = "http://64.34.161.181/download/1.5.0/sources/${P}.tar.gz"
inherit autotools
S = "${WORKDIR}/${PN}"
SRC_URI[md5sum] = "b5d0a97f8010f5e4047cccce971f2101"
SRC_URI[sha256sum] = "b1ab0412d9493b88ca7feb124e4637b2b22841fb8fbae10f67b1ada2b64195fb"
