SRC_URI = "http://64.34.161.181/download/1.5.0/sources/${P}.tar.gz"
inherit autotools
S = "${WORKDIR}/${PN}"
SRC_URI[md5sum] = "8d2246c016e8ac01b6c539cad792cd27"
SRC_URI[sha256sum] = "94523d33610828d8fadbd779a7a43a5513136dfd93ec9fd287f3c454797d4e77"
