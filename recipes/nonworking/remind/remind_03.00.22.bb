SRC_URI = "http://www.roaringpenguin.com/penguin/remind-${PV}.tar.gz"

SRC_URI[md5sum] = "5655ad8209f8453443d0b95658cd82ca"
SRC_URI[sha256sum] = "aba8d57738d74b8f194deda442e1e2feb8f5ee452e13828cc950e66948957466"

inherit autotools

