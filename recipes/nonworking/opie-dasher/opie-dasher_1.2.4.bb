require ${PN}.inc
PR = "r1"


SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_inputmethods_dasher.tar.bz2 \
           http://sources.openembedded.org/opie-1.2.4-split_share.tar.bz2"
