SRC_URI = http://www.redland.opensource.ac.uk/dist/source/old/redland-${PV}.tar.gz

inherit autotools

SRC_URI[md5sum] = "d78c768825df2727aec8336fe9772d8d"
SRC_URI[sha256sum] = "0b728f38a29e7abfce192883e86006a8100e9207dc822ea5a5c104290b4c30a4"
