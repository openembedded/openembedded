SRC_URI = http://www.redland.opensource.ac.uk/dist/source/old/redland-${PV}.tar.gz

inherit autotools

SRC_URI[md5sum] = "ad7016755bd1b4203649d002f8715193"
SRC_URI[sha256sum] = "c16dba38cb864a1c429542068dde7ed1bb6a3feb48a2aac1d89cdb6388fd268d"
