SECTION = "base"
require e2fsprogs-libs_${PV}.bb
inherit native

PACKAGES = ""

DEPENDS = "gettext-native"
