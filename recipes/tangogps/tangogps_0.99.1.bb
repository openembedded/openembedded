require tangogps.inc
PR = "r0"

SRC_URI[archive.md5sum] = "bf99c9510481681651434eb943fe3294"
SRC_URI[archive.sha256sum] = "9f1e85c4f90a13ceb66dc8c0e6a92561fb00a8b01f63558b01ae9efdff984a59"
