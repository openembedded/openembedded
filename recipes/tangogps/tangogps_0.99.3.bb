require tangogps.inc

SRC_URI[archive.md5sum] = "74b4f584b6edae576c1d77d166a9476e"
SRC_URI[archive.sha256sum] = "ff8bf63021e54ea7cd5c52382b32877252e5230154606f6235648caf36f51b8f"
