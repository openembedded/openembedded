require tangogps.inc

SRC_URI[archive.md5sum] = "ba0b28f9f87f6b47cf32a4f2c935cc28"
SRC_URI[archive.sha256sum] = "269462ddae9b3837a8f44ae0004a3bbc2aa14feef7c9dfdc8eda55b2f39c0297"
