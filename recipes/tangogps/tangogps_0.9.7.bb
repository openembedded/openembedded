require tangogps.inc
PR = "r2"

SRC_URI_append = " file://maptile-zoom-fix.patch;patch=1"
