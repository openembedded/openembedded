require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_noncore_styles_metal.tar.bz2;name=split_noncore_styles_metal"
SRC_URI[split_noncore_styles_metal.md5sum] = "dbc5f13701e570c6ec06439314d893a9"
SRC_URI[split_noncore_styles_metal.sha256sum] = "ed22e0cdcf04c12aa67f9f1319a824dd7715fe1dd55b3de9c0f1f3e2b0cf875f"
