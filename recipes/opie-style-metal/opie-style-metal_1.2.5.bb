require ${PN}.inc

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_noncore_styles_metal.tar.bz2;name=split_noncore_styles_metal"
SRC_URI[split_noncore_styles_metal.md5sum] = "744e6b771370925cf596ce50b1b241f5"
SRC_URI[split_noncore_styles_metal.sha256sum] = "cbf227964810f89fee4d86ecf56fa877bd5a156cdb1da94cfe0eed9a472099da"
