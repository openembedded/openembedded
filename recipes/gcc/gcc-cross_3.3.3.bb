PR = "r7"

require gcc-${PV}.inc
require gcc-cross.inc
require gcc-configure-cross.inc
require gcc-package-cross.inc


SRC_URI[md5sum] = "3c6cfd9fcd180481063b4058cf6faff2"
SRC_URI[sha256sum] = "9ac6618495b7dd2ff0cd50abd76fe3c51287efcc724340687407f9fc250bdc6a"
