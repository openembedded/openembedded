PR = "r2"

require gcc-${PV}.inc
require gcc-configure-target.inc
require gcc-package-target.inc

SRC_URI[md5sum] = "be1a8a4baeb745af388f4ce09ff7d3e3"
SRC_URI[sha256sum] = "31ca43436520074e90482f54ffe26cc59ea76836add50d8b7d2c1adfefd19845"
