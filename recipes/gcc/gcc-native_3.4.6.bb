PR = "r10"

require gcc-${PV}.inc
require gcc-configure-target.inc
require gcc-native.inc
PROVIDES += "gcc3-native"

SRC_URI[md5sum] = "4a21ac777d4b5617283ce488b808da7b"
SRC_URI[sha256sum] = "7791a601878b765669022b8b3409fba33cc72f9e39340fec8af6d0e6f72dec39"
