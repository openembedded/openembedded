PR = "r8"

OBJC = ""
FORTRAN = ""

require gcc-csl-arm-2005q3.inc
require gcc-cross.inc
