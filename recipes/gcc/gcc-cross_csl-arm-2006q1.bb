PR = "r6"

require gcc-csl-arm-2006q1.inc
require gcc-cross.inc
require gcc-configure-cross.inc
require gcc-package-cross.inc

SRC_URI[md5sum] = "c0d60035d45c7f43d2ddd3c021709220"
SRC_URI[sha256sum] = "693609f59d0c0a6518a3654314aaef841305e029c8f7de4c42fbc0fd7f2dbb35"
