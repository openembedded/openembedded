require gcc-cross_${PV}.bb
require gcc-cross-intermediate.inc

SRC_URI[md5sum] = "e744b30c834360fccac41eb7269a3011"
SRC_URI[sha256sum] = "63dc1c03a107ec73871151bb765da7d5dfc1d699c0d0d6a3d244cf5ccb030913"
