require gcc-cross_csl-arm-2005q3.bb
require gcc-cross-initial.inc

SRC_URI[md5sum] = "3313d991b6cfa993e10b68a6dbda3f0f"
SRC_URI[sha256sum] = "49bb7e3bb94b4ff0b92596c2743db8b7ebef603b26a5b4b4f15bee057ccdb300"
