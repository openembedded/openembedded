PR = "r13"

require gcc_nios2-3.4.6.inc
require gcc-cross.inc
require gcc-configure-cross.inc
require gcc-package-cross.inc

DEPENDS += "elf2flt-cross"

