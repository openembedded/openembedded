PR = "${INC_PR}.1"

require gcc-${PV}.inc
require gcc-configure-target.inc
require gcc-package-target.inc

SRC_URI[md5sum] = "88785071f29ed0e0b6b61057a1079442"
SRC_URI[sha256sum] = "1159457a0e4c054b709547ae21ff624aebab2033e0d9e5bf46c9cf88b1970606"
