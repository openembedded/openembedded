PR = "${INC_PR}.1"

require gcc-${PV}.inc
require gcc-cross.inc
