require gcc-cross-initial_${PV}.bb
require gcc-cross-kernel.inc

SRC_URI[md5sum] = "a1c267b34f05c8660b24251865614d8b"
SRC_URI[sha256sum] = "3f409186acee739641341e5486e30ea9acecc039452e97a9eb850afbc6c3a691"
