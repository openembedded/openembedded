DESCRIPTION = "A TADS interpreter."
HOMEPAGE = "http://www.tads.org
SECTION = "console/network"

SRC_URI = "http://www.tads.org/frobtads/${PN}-${PV}.tar.gz"

inherit autotools

SRC_URI[md5sum] = "c31b44a7bea51f04958358e575bde731"
SRC_URI[sha256sum] = "1aa4fe2f4a8d79f7f4542d96f0b179886c04cbdfd6a972a19ab80437e6150549"
