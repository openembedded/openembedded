LICENSE = "GPL"
inherit gpe

DESCRIPTION = "Displays a summary of appointments and tasks for the day ahead"
DEPENDS = "gtk+ libxrandr libxsettings libxsettings-client libgpewidget libdisplaymigration libeventdb libgpepimc libtododb"
SECTION = "gpe"
PRIORITY = "optional"


SRC_URI[md5sum] = "7cd5e86b94d84a48077ec6ab6357be60"
SRC_URI[sha256sum] = "1b007d46df292109147f4b270a2a555a5e8c2a90804c37028f1e7d10db512729"
