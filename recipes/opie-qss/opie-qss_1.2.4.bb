require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_core_apps_qss.tar.bz2;name=split_core_apps_qss"
SRC_URI[split_core_apps_qss.md5sum] = "eae54a6c89a108edfd06e3095a88f2a3"
SRC_URI[split_core_apps_qss.sha256sum] = "3122d14a2f95908abcc6580c95be00252b4e2dd1ce42bafcd4b120ef0d6a4e74"
