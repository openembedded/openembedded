require giflib_4.1.6.bb

inherit native
