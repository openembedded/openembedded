require quilt-package.inc
PR = "r2"

SRC_URI[md5sum] = "5f8dd5a041ca7c700b16620228f922aa"
SRC_URI[sha256sum] = "de7290f334baf631a14d031df304ee94cfb550aa69e7512aa589d21c2381c7d8"
