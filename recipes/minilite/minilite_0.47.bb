require minilite.inc

SRC_URI[md5sum] = "d0d91387df0897de8304f69af86e9d15"
SRC_URI[sha256sum] = "8cadb3e56c19c3c5bca5e15074deb5ee451d8871d7f72a06c6d24e150ec352f5"
