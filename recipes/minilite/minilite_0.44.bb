require minilite.inc

SRC_URI[md5sum] = "d9da95ba27ad0bd96fc9093f728c9f90"
SRC_URI[sha256sum] = "c32a90c6ffd2f9bf018dde29f3b09d5e1a90369b4128b3e59003892efc72f31e"
