require minilite.inc

SRC_URI[md5sum] = "d81cecf269ad7bab0da960e6e7228332"
SRC_URI[sha256sum] = "2b299425203246090a4949e034f1d0efb3ff99cd1591d0e16c57370a530b361e"
