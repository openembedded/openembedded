require minilite.inc

SRC_URI[md5sum] = "aef833f6f80ccb1c7b6a57a25f3562bc"
SRC_URI[sha256sum] = "b126f705c0be143acb5f14a832fd3e03ec25ae0c102269889b1c386ff77b73db"
