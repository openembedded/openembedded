require minilite.inc

SRC_URI[md5sum] = "d60d58356ed9a9937e21711a9ceb0b79"
SRC_URI[sha256sum] = "a018e95645ceed535e6df7fbf6fc22ba37fa26778f7e58e5ffface625bf97775"
