require ${PN}.inc

SRC_URI[md5sum] = "d42110ae548dae1eea73e83b03a1a936"
SRC_URI[sha256sum] = "243311225a6bdcee065aaabc63334086cdd4298f13def45c7e798201f88d08cc"
