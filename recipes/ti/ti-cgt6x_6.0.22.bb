require ti-cgt6x.inc

PE = "1"
PV = "6_0_22"
PVwithdots = "6.0.22"

SRC_URI[cgt6xbin.md5sum] = "4d447ee431a46052612efd8c767321dd"
SRC_URI[cgt6xbin.sha256sum] = "15022caee83ad27c81a57f13dab4dfc551868876475847ae7a9316ed83782f78"

