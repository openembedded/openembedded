require ti-framework-components.inc

PV = "2_25_02_06"

SRC_URI[fctarball.md5sum] = "0ff9fc152633f6bfbe7ae98902833477"
SRC_URI[fctarball.sha256sum] = "1dc2994b867c76a474fd0c7c82c544d9163f661434ce994542bba9dd2997da6a"

