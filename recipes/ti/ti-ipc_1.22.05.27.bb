require ti-ipc.inc

PV = "1_22_05_27"

SRC_URI[ipcbin.md5sum] = "bd35d75b754f0fc54d7ad74cfc971987"
SRC_URI[ipcbin.sha256sum] = "b61969dc8b5bf01ee6f68151d2c8e123b1b3b425990987fe64288085d8cc15b7"
