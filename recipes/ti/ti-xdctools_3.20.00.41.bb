require ti-xdctools.inc

PV = "3_20_00_41"

SRC_URI[xdcbin.md5sum] = "649cea5126935a6c7757a353617e29f1"
SRC_URI[xdcbin.sha256sum] = "b32b7f53005eab79756ddeba16115b1fea8cfa8d26b4bd3886df7996cebd7005"

