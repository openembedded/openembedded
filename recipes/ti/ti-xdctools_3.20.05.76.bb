require ti-xdctools.inc

PV = "3_20_05_76"

SRC_URI[xdcbin.md5sum] = "875740925c09bdd3b2135928f897465c"
SRC_URI[xdcbin.sha256sum] = "22501febecef0ddec35978337f70e66fb8e7e71acc2dabd576519b84b7c073f3"


