require ti-dspbios.inc

PV = "5_41_09_34"

SRC_URI[biosbin.md5sum] = "e3e1f334224d8d00e36a238dc71026ea"
SRC_URI[biosbin.sha256sum] = "357c2c01855a1f31f70823bc5afc5d9dc63341270df61d0cf905b172db49f718"

