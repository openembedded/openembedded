require ti-cgt6x.inc

PE = "1"
PV = "6_1_15"
PVwithdots = "6.1.15"

SRC_URI[cgt6xbin.md5sum] = "50eb1e44ca5da68ae4917a3972c8f823"
SRC_URI[cgt6xbin.sha256sum] = "1cf705cd79439c0f72e6224a4f164ff386385c64038f8897b2528c41fa1ceaba"

