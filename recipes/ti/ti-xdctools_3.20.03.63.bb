require ti-xdctools.inc

PV = "3_20_03_63"

SRC_URI[xdcbin.md5sum] = "ef3e7ab06dca1d346731d87a6525d2a7"
SRC_URI[xdcbin.sha256sum] = "da5df132c96c8d73c6ca1e03dcd3b854a1850e3abab04749d858d6fbb9111e0f"

