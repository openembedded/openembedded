require ti-codec-engine.inc

PV = "2_26_01_09"

SRC_URI[cetarball.md5sum] = "d6046f29926b949b9eae4599f42dd51e"
SRC_URI[cetarball.sha256sum] = "4db08e47abb62b1180eb2310f5d0bbad2d1f58702a61d157dca5e056388dc7c2"
