require ti-framework-components.inc

PV = "2_25_00_04"

# Full-FC
#SRC_URI[cetarball.md5sum] = "729ede0fd24210d3c5439511fa859d51"
#SRC_URI[cetarball.sha256sum] = "81f815159f3dfda0525be6da543644b02c3610bcb080df170cbd27e2d8420ba2"

# Lite-FC
SRC_URI[fctarball.md5sum] = "9b186aa6b431be08bd8b91926cd91c95"
SRC_URI[fctarball.sha256sum] = "733737f5a0d0ca251993d8c7138378fb9481867a5d6c77ffa7d133673916c30f"

