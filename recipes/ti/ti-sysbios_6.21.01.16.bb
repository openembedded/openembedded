require ti-sysbios.inc

PV = "6_21_01_16"

SRC_URI[sysbiosbin.md5sum] = "411cd0fac224126ed2a81e67fc79c81a"
SRC_URI[sysbiosbin.sha256sum] = "63d2704ff294fe0834411d010d19c0a0bfd0249520f5ee5ddc2c115df2be8ddd"

TI_BIN_UNPK_CMDS="Y: qY:workdir:Y"
