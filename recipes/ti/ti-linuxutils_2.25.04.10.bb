require ti-linuxutils.inc

PE = "1"
PV = "2_25_04_10"

SRC_URI[md5sum] = "3f7640f3c0eaee5a4aac6cdf453a77ff"
SRC_URI[sha256sum] = "173170c8ce130c3011c8a124d4307999d7b12958cedf51dbf5ce5bfff2d38256"

