require ti-xdctools.inc

PV = "3_16_00_80"

SRC_URI[xdcbin.md5sum] = "1b4fa459713d94c10297094ecb7cef1e"
SRC_URI[xdcbin.sha256sum] = "0c50b47de965bffc03f209659c87d6c8561cd76c58e794634857c7b69f4754b6"

