require matrix-gui-e.inc

SRCREV = "146"
PV = "1.2"
PR = "${INC_PR}.0"

