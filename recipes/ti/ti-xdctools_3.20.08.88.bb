require ti-xdctools.inc

PV = "3_20_08_88"

SRC_URI[xdcbin.md5sum] = "068447e935adb54f0cacf0e294a281f9"
SRC_URI[xdcbin.sha256sum] = "a4616fae3cc2a9f46b5b4377bb57af7f7932297cda210a6cbcc5f942256db196"
