require ti-audio-soc-example.inc

PV = "1_00_00_02"

SRC_URI[audiosoctarball.md5sum] = "980fead72fbd5999c97d9ae2ffe5017a"
SRC_URI[audiosoctarball.sha256sum] = "70dff0c4fa3a7d450d6939eacdc2b8a7fbae867778693d14dcccbbcfd039b0f5"
