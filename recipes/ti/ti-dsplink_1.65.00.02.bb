require ti-dsplink.inc

PE = "1"
PV = "1_65_00_02"
PV_dot = "1.65.00.02"
PV_major = "1_65"

PV_DL_PATH = "DSPLink/${PV_major}/${PV}/${PV_dot}"

SRC_URI[dsplinktarball.md5sum] = "e05b1f2b2b4a1a92c15746e9c541a80f"
SRC_URI[dsplinktarball.sha256sum] = "49cce94fb9e0ba103c48802c9203611d9101f08858d8cd91fb162c998f7190d3"

