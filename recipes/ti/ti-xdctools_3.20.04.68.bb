require ti-xdctools.inc

PV = "3_20_04_68"

SRC_URI[xdcbin.md5sum] = "95b2c966b858e7c4b06aa196ac30da34"
SRC_URI[xdcbin.sha256sum] = "5e1d048f8ed7f7d2f21a9c35a9903a00b1b9b2011c0fd792f251987d84ae8075"

