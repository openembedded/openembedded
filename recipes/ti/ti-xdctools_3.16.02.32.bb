require ti-xdctools.inc

PV = "3_16_02_32"

SRC_URI[xdcbin.md5sum] = "110803859243385090520fc119cb27c3"
SRC_URI[xdcbin.sha256sum] = "0a3db1d117a1a459d32e7b4feae032a36abc4243fcbbedb0a02d8cfed1767f28"

