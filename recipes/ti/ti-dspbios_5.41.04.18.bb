require ti-dspbios.inc

PV = "5_41_04_18"

SRC_URI[biosbin.md5sum] = "dd9c6a595b982e6af313f788040c8b3e"
SRC_URI[biosbin.sha256sum] = "21575ddd96165c9650083554b400e6274e816c8ca9e5f51853da3463c045d136"

