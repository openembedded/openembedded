require ti-ipc.inc

LIC_FILES_CHKSUM = "file://ipc_1_23_02_27_manifest.html;md5=74cbdd9a526809df81e080f19b36eec7"

PV = "1_23_02_27"

SRC_URI[ipcbin.md5sum] = "8c45f6a81cef62f9717335911ee1c9cd"
SRC_URI[ipcbin.sha256sum] = "b16f29ef016819fe0632468e2f756e05508143cbc732bcaabd269571163b568e"

