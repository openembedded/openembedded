require ti-cgt6x.inc

PE = "1"
PV = "7_0_4"
PVwithdots = "7.0.4"

SRC_URI[cgt6xbin.md5sum] = "5de4f1053eb18516b03e267b257a83b8"
SRC_URI[cgt6xbin.sha256sum] = "9c2da66c5adaf3b2812db3b9eb53c404218e00e12a77102bf9bde386d76e6cb7"

