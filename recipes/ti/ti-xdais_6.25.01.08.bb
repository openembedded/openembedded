require ti-xdais.inc

PV = "6_25_01_08"

SRC_URI[xdaistarball.md5sum] = "5f284e0721f4f080c9adc6271387c0f9"
SRC_URI[xdaistarball.sha256sum] = "88866b1bbd3992141f47f7a672cd4a2fbeef729d582312a06a1f269a32dded88"

