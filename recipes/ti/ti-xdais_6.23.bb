require ti-xdais.inc

PV = "6_23"


