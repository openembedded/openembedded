require ti-cgt6x.inc

PE = "1"
PV = "7_0_3"
PVwithdots = "7.0.3"

SRC_URI[cgt6xbin.md5sum] = "72068fd3eaeaba8344a57366be592c32"
SRC_URI[cgt6xbin.sha256sum] = "97b4b9b7e873f3295eb1a051abcc3a761e414823910c574c3fa9077f5084fb4d"

