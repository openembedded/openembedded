require ti-xdais.inc

PV = "7_20_00_07"

SRC_URI[xdaistarball.md5sum] = "3f3080e7b63dfb5d8d21654a6690cba3"
SRC_URI[xdaistarball.sha256sum] = "bd64cf052d186b228c9ea26fec60d59527877a3e216fc82d76639bc3043ca275"

