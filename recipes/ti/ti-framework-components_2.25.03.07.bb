require ti-framework-components.inc

PV = "2_25_03_07"

SRC_URI[fctarball.md5sum] = "2b89d86098fd99dfc99b546da4251eb2"
SRC_URI[fctarball.sha256sum] = "bc5834ccfddb14cf1cca47e07bcc4993733785825962583747d8f6b5a4372940"


