require ti-cgt6x.inc

PE = "1"
PV = "7_0_2"
PVwithdots = "7.0.2"

SRC_URI[cgt6xbin.md5sum] = "a57518ffdde50110f8a7e6f0c354d7c4"
SRC_URI[cgt6xbin.sha256sum] = "7a6f3a93f197218417411c9d66f6fdcc877f5e9778852494823434612721f36f"

