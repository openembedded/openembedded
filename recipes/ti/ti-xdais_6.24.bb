require ti-xdais.inc

PV = "6_24"

SRC_URI[xdaisgz.md5sum] = "a336c79bc86bd345436e482b3def5e47"
SRC_URI[xdaisgz.sha256sum] = "85eebf29bb4a2add2a7c2335880bad6262be87d3fd3d79ae9c47dea611ebbf13"

