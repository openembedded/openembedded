require ti-dspbios.inc

PV = "5_41_06_21"

SRC_URI[biosbin.md5sum] = "4b5214b976db112aed3592e432f2a049"
SRC_URI[biosbin.sha256sum] = "432c232224c62198be429f4efae76e23feb40b686de71440504ac7378c36f85b"

