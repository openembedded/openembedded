require ti-xdctools.inc

PV = "3_16_03_36"

SRC_URI[xdcbin.md5sum] = "239da86ef7a70d920a1f9ea6ea5afc6e"
SRC_URI[xdcbin.sha256sum] = "7d18f3b02f4d49045184af0a7e093e5ef8c2c11fa21fd044d61c4f382b20336c"

