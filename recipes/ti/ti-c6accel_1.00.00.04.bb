require ti-c6accel.inc

PV = "1_00_00_04"

SRC_URI[c6accelbin.md5sum] = "a1146d7b23252b4ac2ff927d79dcdc4b"
SRC_URI[c6accelbin.sha256sum] = "c558ad170315b8706a9639a056a38b12c42b8ae9bb909e6529591a69c82cc789"

