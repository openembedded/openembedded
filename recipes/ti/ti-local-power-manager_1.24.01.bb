require ti-local-power-manager.inc

PV = "1_24_01"
PE = "1"

SRC_URI[lpmtarball.md5sum] = "6699861c8d0195654c539798ec428124"
SRC_URI[lpmtarball.sha256sum] = "052b31b09e6d85bc1e980f5e3d2350019c2d8d7430d24db60854dc926df9a1f2"

