inherit qt4e

require ti-xgxperf.inc

SRCREV = "58"
PV = "1.0.0.0"

