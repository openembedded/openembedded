require ti-cgt6x.inc

PE = "1"
PV = "6_1_12"
PVwithdots = "6.1.12"

SRC_URI[cgt6xbin.md5sum] = "c97691d0d5ced3b9deb5f643475c74c8"
SRC_URI[cgt6xbin.sha256sum] = "5cf5e89fecfeab1b3f97dfb4ade80a333082dc59295dfb167ec4b8b90d214d6d"

