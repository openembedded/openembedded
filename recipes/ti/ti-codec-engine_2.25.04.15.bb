require ti-codec-engine.inc

PV = "2_25_04_15"

SRC_URI[cetarball.md5sum] = "add6f1fa1b49ef8198a8ad3bf572b610"
SRC_URI[cetarball.sha256sum] = "6b297c7267f792ba1f9fb6b69d3c9c1df82af3f23e5a600b251cb2a042b6e429"

