require matrix-gui-common.inc

SRCREV = "146"
PV = "1.2"
PR = "r0"
