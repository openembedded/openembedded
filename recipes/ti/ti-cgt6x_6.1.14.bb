require ti-cgt6x.inc

PE = "1"
PV = "6_1_14"
PVwithdots = "6.1.14"

SRC_URI[cgt6xbin.md5sum] = "966499f31b05e31c05ff5deecd19d53b"
SRC_URI[cgt6xbin.sha256sum] = "dc477a206c3e0b3090504dbcdd78618bc453993a0110e5a20092f98cdff1c0c1"

