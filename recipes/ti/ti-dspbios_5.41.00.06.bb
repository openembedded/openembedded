require ti-dspbios.inc

PV = "5_41_00_06"

SRC_URI[biosbin.md5sum] = "44851393e5858258ff0cd09b062e8f38"
SRC_URI[biosbin.sha256sum] = "f35853b8ecbd8434ba96d1cc2b329451662d0059ab328ee11a5170c242d08518"

