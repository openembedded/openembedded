require ti-dspbios.inc

PV = "5_33_06"

SRC_URI[biosbin.md5sum] = "757b35272a894864e463086565056cd7"
SRC_URI[biosbin.sha256sum] = "52136fce50becd7ae711eebe8943f8a62d06d18f03f374aad8129a6e3dc7e887"

