BASE_PV = "3_15"
PV = "3_15_01_59"

require ti-xdctools.inc
SRC_URI = "http://software-dl.ti.com/dsps/dsps_public_sw/sdo_sb/targetcontent/rtsc/xdctools_${BASE_PV}/exports/xdctools_setuplinux_${PV}.bin"


