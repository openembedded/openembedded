require ti-xdais.inc

PV = "7_10_00_06"

SRC_URI[xdaistarball.md5sum] = "59f3d484e55928b7bb95a0794d360ac2"
SRC_URI[xdaistarball.sha256sum] = "accef8f0141741436137a1b01d280746e1ddf75abf73cb29e7575dfc860b02a3"

