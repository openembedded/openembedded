require ti-cgt6x.inc

PE = "1"
PV = "6_0_23"
PVwithdots = "6.0.23"

SRC_URI[cgt6xbin.md5sum] = "5cf2098a6ed87997092c353e37421ad2"
SRC_URI[cgt6xbin.sha256sum] = "146cc77fb748237672b18d51cb54897500040ba2df4f24d357f4ee10c17177c7"

