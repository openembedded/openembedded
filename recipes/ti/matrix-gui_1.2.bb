require matrix-gui.inc

SRCREV = "146"
PV = "1.2"
PR = "${INC_PR}.0"
