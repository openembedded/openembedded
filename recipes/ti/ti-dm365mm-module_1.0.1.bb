
require ti-dm365mm-module.inc

PV = "01_00_01"

#This is a kernel module, don't set PR directly
MACHINE_KERNEL_PR_append = "a"


