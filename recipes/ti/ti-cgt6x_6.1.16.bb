require ti-cgt6x.inc

PE = "1"
PV = "6_1_16"
PVwithdots = "6.1.16"

SRC_URI[cgt6xbin.md5sum] = "853bb9fa5bf5a8bb64bcf0b09bc9df80"
SRC_URI[cgt6xbin.sha256sum] = "04a64b13fff260bf721c282a8005a7661cb127c2d39896ff42db455ea8f708a2"

