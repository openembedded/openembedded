require ti-dspbios.inc

PV = "5_41_08_30"

SRC_URI[biosbin.md5sum] = "a4a5b58fb5d1fae86c2798adfffc1d45"
SRC_URI[biosbin.sha256sum] = "b78596c7d8b48d5d11893214d0d2e6b223d5f1989740b9e3c541207ffdbe20e3"

