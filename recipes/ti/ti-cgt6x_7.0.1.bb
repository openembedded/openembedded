require ti-cgt6x.inc

PE = "1"
PV = "7_0_1"
PVwithdots = "7.0.1"

SRC_URI[cgt6xbin.md5sum] = "a2e07b3ec5d20df5697788dd4c9cbd77"
SRC_URI[cgt6xbin.sha256sum] = "6e0308107dbd6324bef0171d33eefe8ab4366870669061c7f3d87bd59c93b4ac"

