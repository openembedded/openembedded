require ti-codec-engine.inc

DEFAULT_PREFERENCE = "-1"

PV = "2_25_00_01"
PR = "r20"

do_compile () {
        echo "! Do not rebuild for now !"
}

