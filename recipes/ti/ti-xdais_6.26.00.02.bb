require ti-xdais.inc

PV = "6_26_00_02"

SRC_URI[xdaistarball.md5sum] = "879607ace2513067fa0f5ba16a0cdbbb"
SRC_URI[xdaistarball.sha256sum] = "5f0378787e2b5ff377ec8e0ff6fb39315d378bc6a30c0ff2f5702715cfa313df"


