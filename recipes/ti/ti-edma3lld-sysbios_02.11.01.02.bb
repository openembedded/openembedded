require ti-edma3lld-sysbios.inc

PV = "02_11_01_02"

SRC_URI[md5sum] = "270c15dc5f0a5761adb1ff45ab1adb99"
SRC_URI[sha256sum] = "bd76114114a099eba15bdce8e3815a8cd2c01d819ebfc630f6abdd39da36b525"
