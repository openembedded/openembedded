require matrix-gui-e.inc

SRCREV = "245"
PR = "${INC_PR}.8"

