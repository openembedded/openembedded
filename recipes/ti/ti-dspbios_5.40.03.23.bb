require ti-dspbios.inc

PV = "5_40_03_23"

SRC_URI[biosbin.md5sum] = "7dbdcc8f44ce01c64e6b8f4d23f84bf1"
SRC_URI[biosbin.sha256sum] = "85534d2cc6eccb43b59ee3d15e4ad95cd4331684b15e776b59be50a4250c0240"

