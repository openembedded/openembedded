require ti-xdctools.inc

PV = "3_15_04_70"

SRC_URI[xdcbin.md5sum] = "855a3b41d703a5c4e707d6ba9a23f94d"
SRC_URI[xdcbin.sha256sum] = "e4eb68e62fc2774c1a4d0b19e4375e83cf39d249901647c86100930f511550a5"

