require ti-xdctools.inc

PV = "3_16_01_27"

SRC_URI[xdcbin.md5sum] = "10d5ef7490cda01978205175cb43a618"
SRC_URI[xdcbin.sha256sum] = "48f460eb64c092ff3f72b290457d69cd46a538e0a9086989584f1f0d2da32d54"


