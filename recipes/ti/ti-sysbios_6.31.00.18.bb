require ti-sysbios.inc

PV = "6_31_00_18"

SRC_URI[sysbiosbin.md5sum] = "a37fe51f208d7cb63a6fae09d3285c69"
SRC_URI[sysbiosbin.sha256sum] = "2d5cedffdc554e545ee9e233ba760e95b97904f6ea0ca3dbdd56a422b05e2b62"

TI_BIN_UNPK_CMDS="Y: qY:workdir:Y"
