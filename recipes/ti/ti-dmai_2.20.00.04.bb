require ti-dmai.inc

PV = "2_20_00_04"
PR = "r3"
 
COMPATIBLE_MACHINE = "(da850-omapl138-evm|da830-omapl137-evm)"
SRCREV         = "500"
DMAIBRANCH     = "tags/TAG_2_20_00_04"

