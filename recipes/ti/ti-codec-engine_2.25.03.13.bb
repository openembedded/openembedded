require ti-codec-engine.inc

PV = "2_25_03_13"

SRC_URI[cetarball.md5sum] = "bb79f7ab90093364043d983f5bb312ba"
SRC_URI[cetarball.sha256sum] = "da31c03917ba6c887da8f0548cf7a8782e525fb088dc727d1df6427da629ac7f"

