require ti-framework-components.inc

PV = "2_25_01_05"

# Full-FC
#SRC_URI[cetarball.md5sum] = "729ede0fd24210d3c5439511fa859d51"
#SRC_URI[cetarball.sha256sum] = "81f815159f3dfda0525be6da543644b02c3610bcb080df170cbd27e2d8420ba2"

# Lite-FC
SRC_URI[fctarball.md5sum] = "50a50a328471cfacf11aeb071671038e"
SRC_URI[fctarball.sha256sum] = "6c2a7bd8ed0d5f4be688b8fa5dd80d98e43f7327f54e9a758a04df0695ef15d8"

