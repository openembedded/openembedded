require ti-xdctools.inc

PV = "3_16_05_41"

SRC_URI[xdcbin.md5sum] = "4a460d7974f271c2e686ada8ddf2a117"
SRC_URI[xdcbin.sha256sum] = "81af530d252b1d9f45f01542059fd55fa756dcc219bb22190f995f3d4b1daa46"

