require ti-codec-engine.inc

PV = "2_25_02_11"

SRC_URI[cetarball.md5sum] = "a696df6d38c27cfba993a2cf617060ef" 
SRC_URI[cetarball.sha256sum] = "928d90603ac8942db2d9d975a3635921b1b4a7b2fd88c922ff3a2cdc31052a93" 

