require ti-cgt6x.inc

PE = "1"
PV = "6_1_13"
PVwithdots = "6.1.13"

SRC_URI[cgt6xbin.md5sum] = "3556466b571cf69630a55632d0436636"
SRC_URI[cgt6xbin.sha256sum] = "3c5d45254f99797419d5b3aeb165cf42ad6a1230cce6c8f95ddc3d124c084853"

