require ti-cgt6x.inc

PE = "1"
PV = "6_1_5"
PVwithdots = "6.1.5"

SRC_URI[cgt6xbin.md5sum] = "65cca91db9c5498ee267755087d0c8fc"
SRC_URI[cgt6xbin.sha256sum] = "9e2392e0ae4ba60c8b9998068c443936ebbc2ea93206b1f15323a4c8a229bbe5"

