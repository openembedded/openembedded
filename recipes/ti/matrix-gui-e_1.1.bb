require matrix-gui-e.inc

COMPATIBLE_MACHINE = "(dm365|omapl138|omap3)"

SRCREV = "136"
PV = "1.1"
PR = "r19"

