require ti-dspbios.inc

PV = "5_41_07_24"

SRC_URI[biosbin.md5sum] = "18301d0e1d351bcece9ce97255b8ff1b"
SRC_URI[biosbin.sha256sum] = "1531dca674154fbe179ad5017555e963bcf3d74a47a0fbf10e8a7009639d6c34"


