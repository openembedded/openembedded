require ti-dspbios.inc

PV = "5_41_01_09"

SRC_URI[biosbin.md5sum] = "469eef8d2221548e9fd90a4ebf923c5c"
SRC_URI[biosbin.sha256sum] = "049856484c1fe60afba5221d9acc61c30b87df5c320a05c47520e9eea49afde9"

