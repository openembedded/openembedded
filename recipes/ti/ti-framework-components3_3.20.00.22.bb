require ti-framework-components3.inc

PV = "3_20_00_22"

SRC_URI[fctarball.md5sum] = "13165d5f68f8bc9ee35de447c748b8ae"
SRC_URI[fctarball.sha256sum] = "8a852707a13c5b2bba4d0dc226d234638da0560ec74c1e68a70c81dac42e143f"


