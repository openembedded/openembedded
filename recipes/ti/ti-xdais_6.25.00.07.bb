require ti-xdais.inc

PV = "6_25_00_07"

SRC_URI[xdaisgz.md5sum] = "ef10494d9f7dfc768edd5b7124d7f93d"
SRC_URI[xdaisgz.sha256sum] = "1f7ad591c742616f087690f7cbdbb0b69e61091050a1f59a152e34dd865e1e23"

