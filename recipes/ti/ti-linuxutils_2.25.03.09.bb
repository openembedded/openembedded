require ti-linuxutils.inc

PE = "1"
PV = "2_25_03_09"

SRC_URI[md5sum] = "4ce632504e9624d33265577c25240ec3"
SRC_URI[sha256sum] = "addd15709235c79e7d3892f313bd7bbb7560d14da98e311de617ad897f6ce387"

