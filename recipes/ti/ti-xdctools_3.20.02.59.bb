require ti-xdctools.inc

PV = "3_20_02_59"

SRC_URI[xdcbin.md5sum] = "4c5e2dd35ce16638e1e4299218b16887"
SRC_URI[xdcbin.sha256sum] = "e123eae76cdb22138462e2b7d55e1ef92f0b22df8a6f955d969610f814c6e8cc"

