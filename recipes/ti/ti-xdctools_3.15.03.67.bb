require ti-xdctools.inc

PV = "3_15_03_67"

SRC_URI[xdcbin.md5sum] = "bc0e3d981eda5e777a15e616494184c1"
SRC_URI[xdcbin.sha256sum] = "18521516765cbca6f3cdcdc3d717fa85a209fae9f09bffe0d105b3f33c59ce9f"

