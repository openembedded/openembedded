PV = "4_20_12"
PV_dot = "4.20.12"

require ti-dvtb.inc

SRC_URI[dvtbtarball.md5sum] = "74d0c71450265e35b963b89528f9bee9"
SRC_URI[dvtbtarball.sha256sum] = "4b35c595ed78d0773077f5b9a0dffda124b8328a4073bf6654ed690a857f48b7"

