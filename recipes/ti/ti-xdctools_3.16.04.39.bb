require ti-xdctools.inc

PV = "3_16_04_39"

SRC_URI[xdcbin.md5sum] = "ed9f6e8a6404521207b1b17f6ee0bc78"
SRC_URI[xdcbin.sha256sum] = "d1de82b2795c5cc86a14c314d25ce1d0346304d485cafad2ed848ec97b427b0a"

