require ti-linuxutils.inc

PE = "1"
PV = "2_25_02_08"

SRC_URI[md5sum] = "9bddf6cfb6d76ba5f096438f3ebb9694"
SRC_URI[sha256sum] = "c037d5646061805da5d9254c2f5a4e4f03767a12a2f1ac7984bfa1cbd02d03f9"
