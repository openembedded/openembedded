require ti-framework-components.inc

PV = "2_26_00_01"

SRC_URI[fctarball.md5sum] = "40b51cade2f9ae6e6f6dca73c17065af"
SRC_URI[fctarball.sha256sum] = "3f7a12a51dfe87310828a31518d7ef8f9039e59269c0ca24f74a68433c235048"


