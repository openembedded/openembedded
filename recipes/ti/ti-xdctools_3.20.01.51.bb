require ti-xdctools.inc

PV = "3_20_01_51"

SRC_URI[xdcbin.md5sum] = "1527c946d7a99320175295c2699a9686"
SRC_URI[xdcbin.sha256sum] = "e289a19d9f4e1b91e0f157527935e4c2ac4c7e02481a718de16f56b569d5450f"

