require ti-cgt6x.inc

PE = "1"
PV = "7_2_2"
PVwithdots = "7.2.2"

SRC_URI[cgt6xbin.md5sum] = "8cbe25f3edbc897ba4a535a416df19bc"
SRC_URI[cgt6xbin.sha256sum] = "7a938083850d05430a9bab4a18c14a7a0ac2ea08e94c652cf1644bb9560ca22e"
