require ti-ipc.inc

PV = "1_22_04_25"

SRC_URI[ipcbin.md5sum] = "aaa7f3776794a92b4226cd923c7cd956"
SRC_URI[ipcbin.sha256sum] = "b33e25e0330719c2857a5ca3abccd03fe1b55a9300b2f825707f2bc64b84c883"
