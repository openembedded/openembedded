require ti-dspbios.inc

PV = "5_41_02_14"

SRC_URI[biosbin.md5sum] = "2a0c4ea4cc57801f666a2664e0510af9"
SRC_URI[biosbin.sha256sum] = "314c79d2b45e5e839b0c1d5a71184756f86658b33fe838c907d960fe2bf49b9b"

