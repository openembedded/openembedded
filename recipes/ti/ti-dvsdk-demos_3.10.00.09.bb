require ti-dvsdk-demos.inc

PV = "3_10_00_09"

DEFAULT_PREFERENCE = "-1"
DEFAULT_PREFERENCE_dm355 = "1"
DEFAULT_PREFERENCE_dm365 = "1"
DEFAULT_PREFERENCE_dm6467 = "1"

SRC_URI[dvsdkdemostarball.md5sum] = "ef4c4e9b4dde03342ab5305e5e6ea871"
SRC_URI[dvsdkdemostarball.sha256sum] = "f2b5a16f618f0fdc778f3df4148feba74a7ecea54318739f885671fa5be8b2b8"
