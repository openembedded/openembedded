require ti-xdais.inc

PV = "6_24_01_06"

SRC_URI[xdaisgz.md5sum] = "a9cfe7ea8e7ff95ef133be762ba76f00"
SRC_URI[xdaisgz.sha256sum] = "8973dc8379c7dcf0a145f9509ca93c2f9b72d40d46d65ac7470d4c71de0245aa"

