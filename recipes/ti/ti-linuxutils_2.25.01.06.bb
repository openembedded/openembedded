require ti-linuxutils.inc

PE = "1"
PV = "2_25_01_06"

SRC_URI[md5sum] = "15486b27c9960f06b53f8a60e90f941d"
SRC_URI[sha256sum] = "61b86cdb5c1b2f9eb766fece6ea5ae89f29cf84d0c3eecbcc9b5d0ffd42d2bcb"
