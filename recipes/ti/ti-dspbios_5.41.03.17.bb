require ti-dspbios.inc

PV = "5_41_03_17"

SRC_URI[biosbin.md5sum] = "b471d26594829d8ad0d10ccb798dad78"
SRC_URI[biosbin.sha256sum] = "9e4b7c8a91a143c6ec9bbb6231b1027f1425cfa834b1212b9ee047dae1726345"

