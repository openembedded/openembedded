require ti-edma3lld.inc

PV = "01_11_00_03"

SRC_URI[edma3lldbin.md5sum] = "49311f1bce99c034bff0ced410cb859b"
SRC_URI[edma3lldbin.sha256sum] = "87cd43406d3a4f1db00e6536b75100150d3a9dcda28ae832f327b8e024d99dc1"

