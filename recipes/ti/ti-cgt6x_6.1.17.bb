require ti-cgt6x.inc

PE = "1"
PV = "6_1_17"
PVwithdots = "6.1.17"

SRC_URI[cgt6xbin.md5sum] = "41ee41cc74800b06705804f7ef901447"
SRC_URI[cgt6xbin.sha256sum] = "7e1c8b67420abf6f2f44786811d0a2b5692e76194743bed714ec9087cc1a75c7"

