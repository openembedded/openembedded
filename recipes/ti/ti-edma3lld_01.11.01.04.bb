require ti-edma3lld.inc

PV = "01_11_01_04"

SRC_URI_edma3lldsite = "sdo_tii/psp"

SRC_URI[edma3lldbin.md5sum] = "b3c41cb946e2e4b94348fc6bcbe30b16"
SRC_URI[edma3lldbin.sha256sum] = "617db3eadff33a88e3d42818c204f379906da3b312bc120092408043e7e2aaeb"

