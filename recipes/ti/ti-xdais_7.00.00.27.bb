require ti-xdais.inc

PV = "7_00_00_27"

SRC_URI[xdaistarball.md5sum] = "83bef0ee575c28d301908c645aabdb8d"
SRC_URI[xdaistarball.sha256sum] = "b1902eac0ebbe6c4dec69ff778d6b8c3faa689e3de8791c4a151724aadd7be0f"

