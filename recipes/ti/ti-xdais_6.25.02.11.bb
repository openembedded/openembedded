require ti-xdais.inc

PV = "6_25_02_11"

SRC_URI[xdaistarball.md5sum] = "33dea671988fa63123f667fd6c0c435d" 
SRC_URI[xdaistarball.sha256sum] = "4a71ec361197bbfc49d592afd17b83d21547c6c12a1f5d6fe48f9539f72d951e" 

