require ti-xdctools.inc

PV = "3_15_02_62"

SRC_URI[xdcbin.md5sum] = "69870ff825c9a9d8122f4f7840951948"
SRC_URI[xdcbin.sha256sum] = "acb3fb85d368fc6f4c004c1aef4c21b0a966eaee01cf290d094c84933716e5e6"

