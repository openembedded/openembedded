require ti-cgt6x.inc

PE = "1"
PV = "6_1_11"
PVwithdots = "6.1.11"

SRC_URI[cgt6xbin.md5sum] = "d6d2184b5b661eceafca779bbc3204af"
SRC_URI[cgt6xbin.sha256sum] = "4afb632e410702410a9ef25124b34d872909747f3aba128be7b6c65c9d6bb371"

