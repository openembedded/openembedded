require libgcrypt.inc

PR = "r2"

SRC_URI[md5sum] = "be20ee47778ff90703afd58c090f07b9"
SRC_URI[sha256sum] = "cf3c3f313ebeb9165d80439beaeb7f621b73856a2159e4b84c70f32b455fd9ec"
