require libgcrypt.inc

PR = "r3"

SRC_URI[md5sum] = "4f80e46b38a71767479a3d953af22bdd"
SRC_URI[sha256sum] = "14d457c3ed1d4751664f7196cbcd20e7db82532025f35634812f0cb7470fc43e"
