require libgcrypt.inc

LICENSE = "GPLv2+ LGPLv2.1+"

PR = "r1"


SRC_URI[md5sum] = "555488ddfc81a6e0df1fb5112e7eee13"
SRC_URI[sha256sum] = "7562042a6210947363bd6a9bbcdd03f8d02470c0347970b507f689d25a907844"
