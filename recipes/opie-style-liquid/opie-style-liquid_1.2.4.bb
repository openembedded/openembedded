require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_noncore_styles_liquid.tar.bz2;name=split_noncore_styles_liquid"
SRC_URI[split_noncore_styles_liquid.md5sum] = "3e16197422a8cc9409444192eefdb299"
SRC_URI[split_noncore_styles_liquid.sha256sum] = "9f14350bc6fa7ddf308181875e58c69ef07a933ed93439d7c0bfc1a590cdcbbe"
