require gpe-timesheet.inc

PR = "r0"

SRC_URI[md5sum] = "dc99875e4bcc5d4c41b0c471270c3736"
SRC_URI[sha256sum] = "9360cadc13eea2906089df5fd5f79d94efb14a72081a3d02ea165ee45a792ae2"
