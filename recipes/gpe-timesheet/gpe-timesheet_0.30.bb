require gpe-timesheet.inc

PR = "r1"

SRC_URI[md5sum] = "52697e77fb05181432f3278424954f25"
SRC_URI[sha256sum] = "addaf005bbcc23482bb655a0bfe476b4cc5fb303c29a7d6633165f3cbea02571"
