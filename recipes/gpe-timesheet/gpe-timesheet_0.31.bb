require gpe-timesheet.inc

PR = "r1"

SRC_URI[md5sum] = "402b0dcfff28bc5d2bfbcf7b1f644afe"
SRC_URI[sha256sum] = "1200fd739898ce71303c758149150910faa803722bd790811b754a48e0ef944d"
