require mtd-utils_${PV}.bb
require mtd-utils-native.inc
DEPENDS += "util-linux-ng-native lzo2-native"
