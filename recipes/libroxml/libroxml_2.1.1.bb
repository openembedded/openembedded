require libroxml.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "dc8342d0490bff5a507dbf1de3426102"
SRC_URI[sha256sum] = "e4e91b610614d6cb1204ac9abbb417368fe84654c7de58134b436cfd00f1a244"
