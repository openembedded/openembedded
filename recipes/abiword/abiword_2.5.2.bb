require abiword-2.5.inc

DEFAULT_PREFERENCE = "-1"

PR = "r1"

RCONFLICTS = "abiword-embedded"

SRC_URI[md5sum] = "bbc9c124f8072875129bd67092f0fa0b"
SRC_URI[sha256sum] = "db34eeb5457fb7572fc76ec2a73cdb4f7a67307e7468b6c4bde820b58c598b3f"
