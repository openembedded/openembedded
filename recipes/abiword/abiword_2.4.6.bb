require abiword.inc

RCONFLICTS = "abiword-embedded"


SRC_URI[md5sum] = "30fbd0a9b539f15f54f90d3812a75266"
SRC_URI[sha256sum] = "98105f03b1f33f26cddbfc18d64b04e64a85db3c861508837ab290d26ca2fed3"
