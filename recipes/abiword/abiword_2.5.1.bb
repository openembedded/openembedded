require abiword-2.5.inc

DEFAULT_PREFERENCE = "-1"

PR = "r2"

RCONFLICTS = "abiword-embedded"

SRC_URI[md5sum] = "11d022458e0e090846b35ed4873c2e6e"
SRC_URI[sha256sum] = "482891fb0e376e2aaeee25afa8b4913e6dc50f4fdc280f9f152b3ee8745d735d"
