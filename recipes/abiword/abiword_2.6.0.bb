require abiword-2.5.inc

RCONFLICTS = "abiword-embedded"
