require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_core_pim_today_plugins_addressbook.tar.bz2;name=split_core_pim_today_plugins_addressbook"
SRC_URI[split_core_pim_today_plugins_addressbook.md5sum] = "8ce7242c071575fd565225c8c82c82b8"
SRC_URI[split_core_pim_today_plugins_addressbook.sha256sum] = "35ad6a529ad50a547e98032b0687c0b6402a0b78b5179e80c9ca262cfe1a7c2f"
