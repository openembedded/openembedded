require wireless-tools.inc

PR = "r3"
