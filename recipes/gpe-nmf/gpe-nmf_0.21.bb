require gpe-nmf.inc

RRECOMMENDS += "gst-plugin-tcp"

SRC_URI[md5sum] = "3181586b20fa77d1bd83024bc0aaa584"
SRC_URI[sha256sum] = "2629167d8d27b083e34a6b39e0c8fffa035c84819f8058fdc6dceab60e3a0cf9"
