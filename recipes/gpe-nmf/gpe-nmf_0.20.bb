require gpe-nmf.inc

RRECOMMENDS += "gst-plugin-tcp"
PR = "r1"

SRC_URI[md5sum] = "28e1ff870af9b38d0cce345d339b857a"
SRC_URI[sha256sum] = "e3f89854fde8db448bd60fad1dce9a89aae994e75fa0cfdf97888891563e7232"
