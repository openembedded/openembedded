require gpe-nmf.inc

PR = "r4"

SRC_URI[md5sum] = "380627dc5b640af23bcc5b25033dc9a8"
SRC_URI[sha256sum] = "ef5e8fe2a95a8ffbf825b6955db8f8028b35f4247bbb3ce089d2a74858d01e3b"
