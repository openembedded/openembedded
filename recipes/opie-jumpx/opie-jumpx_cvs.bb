require ${PN}.inc

PV = "${OPIE_GIT_PV}"

SRC_URI = "${OPIE_GIT};protocol=git;subpath=inputmethods/jumpx \
	   ${OPIE_GIT};protocol=git;subpath=pics"
