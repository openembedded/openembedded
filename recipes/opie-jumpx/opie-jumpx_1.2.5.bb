require ${PN}.inc

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_inputmethods_jumpx.tar.bz2;name=split_inputmethods_jumpx \
	   http://sources.openembedded.org/opie-1.2.5-split_pics.tar.bz2;name=split_pics"
SRC_URI[split_inputmethods_jumpx.md5sum] = "8ba72a07396cc0b922e9e0a74dccbb1d"
SRC_URI[split_inputmethods_jumpx.sha256sum] = "d761e5d3852160b72d0b41acefb970733306c5fa337e849e130cf5c2312adf28"
SRC_URI[split_pics.md5sum] = "e9b68749d67295f7080a23e39b17335e"
SRC_URI[split_pics.sha256sum] = "0a7aab6d0bce04d6a9c257d768d8a1a481d38ba527d6e6e50723973789954b4a"
