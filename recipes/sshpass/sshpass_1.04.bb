PR = "${INC_PR}.0"

require sshpass.inc

SRC_URI[md5sum] = "87e7c72e319691c5fdf219f6c7effb4a"
SRC_URI[sha256sum] = "e8abb9a409f25928722251a5855a74854f6d64af3eb136b804a04fd630d70c80"
