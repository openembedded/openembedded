require networkmanager.inc

PR = "r5"
