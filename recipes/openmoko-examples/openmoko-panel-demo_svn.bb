DESCRIPTION = "An example panel plugin for Openmoko"
SECTION = "openmoko/examples"
DEPENDS += "libmatchbox"
PV = "0.0.1+svnr${SRCPV}"

inherit openmoko

PARALLEL_MAKE = ""

