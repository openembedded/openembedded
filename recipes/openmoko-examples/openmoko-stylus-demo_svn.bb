DESCRIPTION = "An example stylus application for Openmoko"
SECTION = "openmoko/examples"
PV = "0.0.1+svnr${SRCPV}"

inherit openmoko

