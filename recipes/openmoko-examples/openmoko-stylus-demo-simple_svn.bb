DESCRIPTION = "A simple stylus application example for Openmoko"
SECTION = "openmoko/examples"
PV = "0.0.1+svnr${SRCREV}"

inherit openmoko

