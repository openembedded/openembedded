DESCRIPTION = "An example finger application for Openmoko"
SECTION = "openmoko/examples"
PV = "0.0.1+svnr${SRCREV}"

inherit openmoko

