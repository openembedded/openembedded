require dropbear.inc

PR = "${INC_PR}.0"

SRC_URI += "file://scp-argument-fix.patch;patch=1"
