require qtnx.inc
inherit qt4e

SRC_URI[md5sum] = "777b3cda7a245e3870d4870a9460cb73"
SRC_URI[sha256sum] = "dfc6c8dd89c26171411d8f7fa92613004eb8947ff509459151fdb03de7fe9608"
