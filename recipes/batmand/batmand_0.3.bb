require batmand.inc
PR = "${INC_PR}.1"


SRC_URI[md5sum] = "54812e81f70a4155edcce88f0c7aeb02"
SRC_URI[sha256sum] = "846f34019c6f30bbb88790088a0e205c7a4e7ee0ab656a5ea3b4b624a0a028cb"
