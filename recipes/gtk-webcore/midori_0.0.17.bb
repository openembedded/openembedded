require midori.inc           

SRC_URI += "file://webkit-update.patch;patch=1"

PE = "1"

