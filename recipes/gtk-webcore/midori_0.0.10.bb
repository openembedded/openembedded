require midori.inc

PE = "1"
