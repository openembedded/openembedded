require midori.inc

PR = "r2"
PE = "1"

SRC_URI += "file://desktop.patch;patch=1"

