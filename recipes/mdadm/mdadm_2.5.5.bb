require mdadm.inc
PR = "r0"


SRC_URI[mdadm-2.5.5.md5sum] = "099bb5f340c5d334445dd003a6d86460"
SRC_URI[mdadm-2.5.5.sha256sum] = "d54ae28bdafdbd3c71bfafa8f8814583356714b6a1436783161413a1e34a38c9"
