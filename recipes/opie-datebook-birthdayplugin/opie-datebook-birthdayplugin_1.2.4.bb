require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_core_pim_datebook_holiday_birthday.tar.bz2;name=split_core_pim_datebook_holiday_birthday"
SRC_URI[split_core_pim_datebook_holiday_birthday.md5sum] = "c2a42fdb8459e419d18f82263331d0f2"
SRC_URI[split_core_pim_datebook_holiday_birthday.sha256sum] = "60e0aa6d16fd0e785ce4cc6e48f44bd7a033dc0486af6f5e6775106f416214b4"
