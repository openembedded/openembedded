DESCRIPTION = "StreamRipper lets you record streaming mp3 to your hard drive."
SECTION = "console/multimedia"
LICENSE = "GPL"

SRC_URI = "${SOURCEFORGE_MIRROR}/streamripper/streamripper-${PV}.tar.gz"

inherit autotools


SRC_URI[md5sum] = "57cd09098917bda29f841d366649681c"
SRC_URI[sha256sum] = "1747aee9fa4cc09b49e0fb14baace3293f8f870c0de27fd3550cde21d99e9cd7"
