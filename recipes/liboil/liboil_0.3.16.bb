require liboil.inc

SRC_URI =+ "file://autotools.patch;patch=1"
