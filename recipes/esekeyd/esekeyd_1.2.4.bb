DESCRIPTION = "ESE Key Daemon"
LICENSE = "GPL"
SECTION = "base"
HOMEPAGE = "http://www.burghardt.pl"

SRC_URI = "http://www.burghardt.pl/files/esekeyd-${PV}.tar.gz"

inherit autotools 

