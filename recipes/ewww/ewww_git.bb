DESCRIPTION = " Enlightenment webbrowser"
LICENSE = "GPL"
DEPENDS = "webkit-efl evas ecore edje"
SRC_URI = "git://git.profusion.mobi/users/gustavo/ewww.git;protocol=git"
PV="0.0.1"
PR="r0"

inherit autotools
