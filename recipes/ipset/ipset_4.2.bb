PR = "${INC_PR}.0"
require ipset.inc

SRC_URI[md5sum] = "9060d549a18c1c0794fa47a71343d627"
SRC_URI[sha256sum] = "5f1b9e5245b7998106660a5b29d9580156feda1c669e7214793a90e02e4a1203"

