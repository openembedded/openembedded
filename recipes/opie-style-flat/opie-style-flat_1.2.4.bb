require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_noncore_styles_flat.tar.bz2;name=split_noncore_styles_flat"
SRC_URI[split_noncore_styles_flat.md5sum] = "f85a5a4e4be7ade9f1eb306484ae2cf1"
SRC_URI[split_noncore_styles_flat.sha256sum] = "84e6194fafaa543f67b81b583c966cd2922888efe1bb147422fd056b72669575"
