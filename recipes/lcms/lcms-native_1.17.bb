require lcms_${PV}.bb

PR = "r0"

inherit native

SRC_URI[md5sum] = "07bdbb4cfb05d21caa58fe3d1c84ddc1"
SRC_URI[sha256sum] = "5ef3b4dab30956772009e29dba33fe1256cf9da161106a1e70b0966c96d14583"
