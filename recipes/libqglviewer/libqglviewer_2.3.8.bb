require libqglviewer.inc

PR = "${INC_PR}.0"
