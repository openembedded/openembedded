require libtheora.inc

PR = "${INC_PR}.0"
 
SRC_URI += "file://no-docs.patch;patch=1"


SRC_URI[md5sum] = "292ab65cedd5021d6b7ddd117e07cd8e"
SRC_URI[sha256sum] = "b6ae1ee2fa3d42ac489287d3ec34c5885730b1296f0801ae577a35193d3affbc"
