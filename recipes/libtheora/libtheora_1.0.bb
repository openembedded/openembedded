require libtheora.inc

PR = "${INC_PR}.0"

SRC_URI += "file://libtheora-1.0-no-docs.patch;patch=1"


SRC_URI[md5sum] = "c963937053f45a7878954bed37ceb182"
SRC_URI[sha256sum] = "3ae9df56e8fc75ffe26e63a13cae2ce79d079416175fb0baffe0e2de8dc91a6d"
