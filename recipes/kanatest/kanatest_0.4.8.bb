require kanatest.inc

PR = "r0"
