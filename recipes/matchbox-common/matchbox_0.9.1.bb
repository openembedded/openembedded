DESCRIPTION = "Metapackage for Matchbox suite"
LICENSE = "GPL"
RDEPENDS_${PN} = "matchbox-common matchbox-wm matchbox-panel matchbox-desktop"
SECTION = "x11/wm"
PR = "r1"

ALLOW_EMPTY = "1"
