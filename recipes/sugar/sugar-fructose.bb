DESCRIPTION = "Sugar fructose activities"

DEPENDS = "etoys"
