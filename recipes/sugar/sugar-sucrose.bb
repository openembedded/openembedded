DESCRIPTION = "Complete sugar environment with core activities"

#DEPENDS = "sugar sugar-fructose"
DEPENDS = "sugar"
