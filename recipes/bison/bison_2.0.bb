require bison.inc

PR = "${INCPR}.0"

SRC_URI[md5sum] = "c17f964fd5504b88b07a183420de25e3"
SRC_URI[sha256sum] = "31b816846903d319a6f6cd1c9aada5ff83914206cb7df69c235ae909785109a1"
