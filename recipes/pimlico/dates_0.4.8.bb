require dates.inc

SRC_URI = "http://pimlico-project.org/sources/dates/dates-${PV}.tar.gz \
	  "

SRC_URI[md5sum] = "b403d18de47018321333bcf994dbe1b0"
SRC_URI[sha256sum] = "e9353d8b52127b02f83e8d9ac3c4b399ff92f57ac68baef9dda1c602bf60bb18"
