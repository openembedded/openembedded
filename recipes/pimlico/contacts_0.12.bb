require contacts.inc

SRC_URI = "http://pimlico-project.org/sources/${PN}/${PN}-${PV}.tar.gz \
	   file://stock_contact.png \
	   file://stock_person.png  \
	  "
SRC_URI[md5sum] = "9615e17535a115dad741a9e38c34f746"
SRC_URI[sha256sum] = "75d3b52753d3ee036632eb98ca8dd052f205130c37b48337dc0b64b3d014ee6e"
