require avahi.inc

DEPENDS += "intltool-native"
PR = "r10"

PACKAGES =+ "libavahi-gobject"

SRC_URI[md5sum] = "c84b1a8a23126e188426728710414dc8"
SRC_URI[sha256sum] = "9dc6f870b6ce050059054a26bfc15d6e7a836fa299edd1b89c63c1089bfedd52"
