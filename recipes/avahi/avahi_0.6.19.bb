require avahi.inc

PR = "r10"

SRC_URI[md5sum] = "a06782435d1c994ecd00a66e95a5d9d4"
SRC_URI[sha256sum] = "a742dceda38f242f5eac72f2c3bc1bda76adf497d6913e88a9cbc624bf2dd68a"
