require avahi.inc

PR = "r1"

DEPENDS += "intltool-native"

PACKAGES =+ "libavahi-gobject"
