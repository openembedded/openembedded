require avahi.inc

PR = "r1"

DEPENDS += "intltool-native"

PACKAGES =+ "libavahi-gobject"

SRC_URI[md5sum] = "068c1d220b07037e64caf87d4a7a0504"
SRC_URI[sha256sum] = "260070d46188ed58f5dc1174ce632c096679f6391a2b729366e7aba349d4b950"
