require avahi.inc

PR = "r10"
