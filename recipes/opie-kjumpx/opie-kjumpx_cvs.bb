require ${PN}.inc

PV = "${OPIE_GIT_PV}"

SRC_URI = "${OPIE_GIT};protocol=git;subpath=inputmethods/kjumpx \
	   ${OPIE_GIT};protocol=git;subpath=pics"
