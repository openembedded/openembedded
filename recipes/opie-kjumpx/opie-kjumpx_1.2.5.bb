require ${PN}.inc

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_inputmethods_kjumpx.tar.bz2 \
	   http://sources.openembedded.org/opie-1.2.5-split_pics.tar.bz2"
