require ${PN}.inc

PR = "r1"

SRC_URI = "${HANDHELDS_CVS};tag=${TAG};module=opie/inputmethods/kjumpx \
	   ${HANDHELDS_CVS};tag=${TAG};module=opie/pics"
