LICENSE    =	"LGPL"

DEPENDS =	""
SRC_URI =	"http://stage.maemo.org:80/pool/maemo/ossw/source/o/${PN}/${PN}_${PV}-1.tar.gz"

inherit autotools pkgconfig

SRC_URI[md5sum] = "e24a9a9fb2167197ad6d141c891be9cf"
SRC_URI[sha256sum] = "c243adca37a6b80e1ccd43da53e61d1794d4dede6787c9beebacd2c1932271ce"
