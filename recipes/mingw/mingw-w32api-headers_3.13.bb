require mingw-w32api_${PV}.bb

require mingw-w32api-headers.inc
