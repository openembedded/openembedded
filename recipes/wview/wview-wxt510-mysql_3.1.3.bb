require wview-common.inc
require wview-mysql.inc
EXTRA_OECONF += " --enable-station-wxt510"
