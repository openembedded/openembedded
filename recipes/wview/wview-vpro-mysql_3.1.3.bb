require wview-common.inc
require wview-mysql.inc
EXTRA_OECONF += " --enable-station-vpro"

SRC_URI[md5sum] = "07f76102b9798f7a01cb35663589896f"
SRC_URI[sha256sum] = "9dcbe3c0006ea63012c5a57720128170bef39b72d8e98e79ccbee202a3e7323f"
