require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_core_pim_today_plugins_todolist.tar.bz2;name=split_core_pim_today_plugins_todolist"
SRC_URI[split_core_pim_today_plugins_todolist.md5sum] = "735c26490b0632bb6b679f5f9694f4a1"
SRC_URI[split_core_pim_today_plugins_todolist.sha256sum] = "aedd38428f1f2932feb539324118b63d4430a7563e0f3e3fac89446cfae89243"
