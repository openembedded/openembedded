require ${PN}.inc

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_core_pim_today_plugins_todolist.tar.bz2;name=split_core_pim_today_plugins_todolist"
SRC_URI[split_core_pim_today_plugins_todolist.md5sum] = "c25f16a66d274e04e17bb58af141948b"
SRC_URI[split_core_pim_today_plugins_todolist.sha256sum] = "e0258dc7fddf6095f42ed756f6b02f5c7dfce52665ab1cf02440f8b0d3038623"
