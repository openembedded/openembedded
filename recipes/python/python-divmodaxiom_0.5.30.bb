DESCRIPTION = "An object oriented database"
LICENSE = "MIT"

REALPN = "Axiom"

DEPENDS += "python-divmodepsilon-native"

require divmod.inc
