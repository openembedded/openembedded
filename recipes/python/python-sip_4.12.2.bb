require python-sip.inc
PR = "r0"

SRC_URI[md5sum] = "9df80f88e0e4022cdd8a8891c6c38048"
SRC_URI[sha256sum] = "3e42bea028a1713558b5b8a317af4195d3b0feaa6c179d99401a7048f1a3cec4"



