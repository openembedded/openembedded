require python-sip.inc
PR = "ml0"

SRC_URI[md5sum] = "597d7ff7edb42a18421c806ffd18a136"
SRC_URI[sha256sum] = "7faaccb6f17296399051bd076a7f41e0f6d95a28eda3e30468f1bd7cf45898e1"
