DESCRIPTION = "Fast JSON encoder/decoder for Python"
SECTION = "devel/python"
LICENSE = "LGPL"
PR = "0"

SRC_URI = "http://pypi.python.org/packages/source/p/python-cjson/python-cjson-${PV}.tar.gz"

inherit distutils
