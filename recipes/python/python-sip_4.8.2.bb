require python-sip.inc
DEFAULT_PREFERENCE = "-1"
PR = "ml0"
