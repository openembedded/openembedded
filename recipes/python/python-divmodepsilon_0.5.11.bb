DESCRIPTION = "A small utility package that depends on tools too recent for Twisted "
LICENSE = "MIT"

REALPN = "Epsilon"

require divmod.inc

