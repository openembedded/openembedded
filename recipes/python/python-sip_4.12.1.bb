require python-sip.inc
PR = "r0"

SRC_URI[md5sum] = "0f8e8305b14c1812191de2e0ee22fea9"
SRC_URI[sha256sum] = "e9d66e8830c2a58e6c17b9952710f67d495ddb84ce6f3d89400c8b52913381b5"


