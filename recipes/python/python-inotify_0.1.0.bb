DESCRIPTION = "Python Linux Inotify Wrapper"
SECTION = "devel/python"
HOMEPAGE = "http://rudd-o.com/projects/python-inotify/"
LICENSE = "GPL"
PR = "ml1"

SRC_URI = "http://rudd-o.com/wp-content/uploads/projects/files/python-inotify/python-inotify-${PV}.tar.gz"

inherit distutils


SRC_URI[md5sum] = "361bcab2f0cd57cdaf6fe6fe433778b0"
SRC_URI[sha256sum] = "22557b44a693918d2a4a4b267b22dd2baa542539e225e3999e1a2b1bf91b954a"
