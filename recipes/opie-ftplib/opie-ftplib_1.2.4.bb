require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_noncore_net_ftplib.tar.bz2;name=split_noncore_net_ftplib"
SRC_URI[split_noncore_net_ftplib.md5sum] = "fc753aa1dccd9ced2da5f359ae6dd2cb"
SRC_URI[split_noncore_net_ftplib.sha256sum] = "9d6d32370949c668c2c9d69cfa253c0effa4dd890719b2433f5370982fe86932"
