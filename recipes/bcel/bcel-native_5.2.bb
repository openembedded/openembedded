require bcel_${PV}.bb

inherit java-native

DEPENDS = "fastjar-native xerces-j-native regexp-native"

