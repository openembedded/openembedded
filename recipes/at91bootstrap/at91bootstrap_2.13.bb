require at91bootstrap_2.0.inc
PR = "r1"
DEFAULT_PREFERENCE = "-1"
DEFAULT_PREFERENCE_at91sam9g45ek = "1"
DEFAULT_PREFERENCE_at91sam9g45ekes = "1"
DEFAULT_PREFERENCE_at91sam9m10ek = "1"



SRC_URI[md5sum] = "1f539d6db38111b6a1d7ab93eb0a648b"
SRC_URI[sha256sum] = "93b01b723ed69f33316384f097da864f5d49c40520c87ccf5537518dbff9df86"
