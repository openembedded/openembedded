require at91bootstrap.inc
PR = "r0"
DEFAULT_PREFERENCE = "-1"
DEFAULT_PREFERENCE_afeb9260 = "1"
DEFAULT_PREFERENCE_afeb9260-180 = "1"
SRC_URI += "file://0001-AFEB9260-support-thumb-support.patch;patch=1"

