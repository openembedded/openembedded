require ${PN}.inc
LICENSE = "LGPL"

PR = "r1"
