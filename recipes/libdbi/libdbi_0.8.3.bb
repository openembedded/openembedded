require ${PN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "ca66db78d479cbfa727cf3245b5864ae"
SRC_URI[sha256sum] = "72e41856bebb1da7b1fd1e6369358c294913f329c5e594e338b3983e6369a5e3"
