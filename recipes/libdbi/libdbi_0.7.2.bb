require ${PN}.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "308e5746a2d0804be1d638319ad7b9c0"
SRC_URI[sha256sum] = "bd518b930f76c976bf693c247f0742d88808c776a2aeb51ab7830dedb0eb692d"
