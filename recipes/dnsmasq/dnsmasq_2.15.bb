PR = "r2"

require dnsmasq.inc

SRC_URI[dnsmasq-2.15.md5sum] = "72f59fa070a1dc7f664603b20134c383"
SRC_URI[dnsmasq-2.15.sha256sum] = "9aec45b395b6206e8eb85417f58186cdd0a307ed0f26f4b73af7031023a52225"
