require dnsmasq.inc

SRC_URI[dnsmasq-2.11.md5sum] = "02aa4ffb835cbc9bdf96fcb915901cb3"
SRC_URI[dnsmasq-2.11.sha256sum] = "2dac596d5150174d0a2d9170db698c1d72584a8ab3b5eedf907086f53f76cc87"
