require dnsmasq.inc

SRC_URI[dnsmasq-2.22.md5sum] = "b38f33cd0703fa664a37a4595d918189"
SRC_URI[dnsmasq-2.22.sha256sum] = "cc2c86cbd0ec020a4486ac9d195e6a848a0d11a280c3194e095719f60c9751a9"
