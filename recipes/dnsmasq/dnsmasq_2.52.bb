require dnsmasq.inc

SRC_URI[dnsmasq-2.52.md5sum] = "1bb32fffdb4f977ead607802b5d701d0"
SRC_URI[dnsmasq-2.52.sha256sum] = "a3724f875d0d30c0e2612a32926ad2b6c0a49fff7e224e737689e4c7e8b323d9"
