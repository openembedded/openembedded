require libmodbus.inc

PR = "${INC_PR}.1"

SRC_URI = "http://github.com/downloads/stephane/libmodbus/libmodbus-${PV}.tar.gz"

SRC_URI[md5sum] = "0646f3edca6d7783d0356dc2fc4f9f4c"
SRC_URI[sha256sum] = "cf9d8d3981ace78a4ed559f2e28c5e0270d56a607b9ae79484e5742e36543feb"
