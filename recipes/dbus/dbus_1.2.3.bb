include dbus.inc

PR = "r0"

SRC_URI[dbus.md5sum] = "f71641385768e99361bd298568207cee"
SRC_URI[dbus.sha256sum] = "16ffaa4a8758f115cf02c78962b0849ed4d802872420fd460c433a9cd580ed1a"
