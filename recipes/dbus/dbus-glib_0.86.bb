require dbus-glib.inc
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "cd0ab148fb0c786fc88be49d19971f50"
SRC_URI[archive.sha256sum] = "5351a6e7f38ffc641c34b4a4cdd9bed1c1dc7043a501096bac00a2876ea90bdc"

