require dbus.inc
PR = "r15"

DEFAULT_PREFERENCE = "-1"
