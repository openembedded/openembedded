require libogg.inc

PR = "${INC_PR}.0"


SRC_URI[md5sum] = "382a7089f42e6f82e7d658c1cb8ee236"
SRC_URI[sha256sum] = "920fa2a0924d66884825d36a2e843de069cfdf1af01945d05da25999bbd6396c"
