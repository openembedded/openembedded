require libogg.inc

PR = "${INC_PR}.0"


SRC_URI[md5sum] = "eaf7dc6ebbff30975de7527a80831585"
SRC_URI[sha256sum] = "bae29e79fbc50bbedf1235852094b71c8c910a1ef0cd42fe4163b7b545630b65"
