require libogg.inc

PR = "${INC_PR}.0"


SRC_URI[md5sum] = "10200ec22543841d9d1c23e0aed4e5e9"
SRC_URI[sha256sum] = "9354c183fd88417c2860778b60b7896c9487d8f6e58b9fec3fdbf971142ce103"
