require libogg.inc

PR = "${INC_PR}.0"

SRC_URI += "file://m4.patch;patch=1"


SRC_URI[md5sum] = "461d7097bf47864b872085a94ff94e10"
SRC_URI[sha256sum] = "01453d561255b5fcb361997904752860e4f8c6b9742f290578a44615fcc94356"
