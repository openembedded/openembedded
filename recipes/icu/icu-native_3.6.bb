require icu-3.6.inc

PR = "${INC_PR}.1"

inherit native
