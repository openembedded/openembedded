LICENSE = "LGPL"
DESCRIPTION = "Application relocator library"
SECTION = "libs"

inherit autotools

SRC_URI = "${GPE_MIRROR}/${PN}-${PV}.tar.bz2"

