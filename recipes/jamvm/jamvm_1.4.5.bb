require jamvm.inc

PR = "r3"

SRC_URI += "file://jamvm-1.3.1-size-defaults.patch;patch=1"


SRC_URI[md5sum] = "3f538bab6e1c77aed331e5e71f754f5b"
SRC_URI[sha256sum] = "f329d1c8f42c06b53a3e82763d33900b100b8e9acd7afe02f7583c51253fd6e5"
