require omapfbplay.inc

OMAPFBPLAYOPTS = "V4L2=y OMAPFB=y NETSYNC=y"
