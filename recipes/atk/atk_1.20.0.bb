require atk.inc

SRC_URI = "http://download.gnome.org/sources/atk/1.20/${PN}-${PV}.tar.bz2"




SRC_URI[md5sum] = "b1a9e28d9f54ea306bd85a4c84b25fb8"
SRC_URI[sha256sum] = "1f3b2f2cbb5b0d8da0924970c66c3ecbfe13c4e4360b0af1db7545401a3747c9"
