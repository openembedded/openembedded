require atk_1.28.0.bb

inherit native

DEPENDS += "glib-2.0-native"

