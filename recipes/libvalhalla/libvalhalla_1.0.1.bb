require libvalhalla.inc
PR = "${INC_PR}.0"

SRC_URI[libvalhalla.md5sum] = "75d4a3383887c4c341eeba9ebe60d626"
SRC_URI[libvalhalla.sha256sum] = "df78015e118c784e3ff3e8562bc96d287ac11997d3b9e45e2d8b67568b0600d3"
