require gnujaf_${PV}.bb

inherit java-native
