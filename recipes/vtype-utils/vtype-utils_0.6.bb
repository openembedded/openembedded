PR = "r0"

inherit gpe

DESCRIPTION = "GPE vtype file tools"
DEPENDS = "libmimedir libgpevtype"
SECTION = "gpe"
PRIORITY = "optional"
LICENSE = "GPL"


SRC_URI[md5sum] = "1bcb6f204f491d3813861dd8760cec61"
SRC_URI[sha256sum] = "51fa4fa2e2a8ecdce773d42d7ecb4bdf33b89a332418059c275b8a9d3fd3e8f9"
