require siproxd.inc

SRC_URI += "file://no-docs.patch;patch=1"
