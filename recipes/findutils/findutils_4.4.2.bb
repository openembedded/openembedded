require findutils.inc
require findutils-alternatives.inc

DEFAULT_PREFERENCE = "-1"

EXTRA_OECONF += " ac_cv_path_SORT=/usr/bin/sort "
