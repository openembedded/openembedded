DESCRIPTION = "Additional packages for Bug Labs repository."

DEPENDS = "\
	curl \
	dosfstools \
	e2fsprogs \
	psmisc \
	rsync \
	time \
	xournal \
	zip \
	openjdk-6 \
	dhcp \
	opencv \
	fbgrab \
	x11vnc \
	jamvm \
	cacao \
	usb-modeswitch \
#	com.buglabs.bug.jni.bluecove \
	"

PR = "r11"
