DESCRIPTION = "Task mamona: Python Applicattions"
LICENSE = "MIT"
PR = "r1"

PACKAGES = "${PN}"

RDEPENDS_${PN} = "\
    python-ao \
    python-cheetah \
    python-constraint \
    python-dbus \
    python-dialog \
    python-pycurl \
    python-fam \
    python-fnorb \
    python-formencode \
    python-fpconst \
    python-gmpy	\
    python-gnosis \
    python-gst \
    python-imaging \
    python-imdbpy \
    python-inotify \
    python-irclib \
    python-logilab-common \
    python-libgmail \
    python-lxml	\
    python-mad \
    python-numarray	\
    python-numeric \
    python-ogg \
    python-pexpect \
    python-pybluez \
    python-pycairo \
    python-pychecker \
    python-pycodes \
    python-pyephem \
    python-pyfits \
    python-pyflakes \
    python-pygobject \
    python-pygoogle \
    python-pygtk \
    python-pyid3lib \
    python-pylinda \
    python-pylint \
    python-pyqt	\
    python-pyraf \
    python-pyrex \
    python-pyro \
    python-pyserial \
    python-pytester \
    python-pyusb \
    python-pyvisa \
    python-pyweather \
    python-pyxml \
    python-pyxmlrpc \
    python-scons \
    python-setuptools \
    python-simplejson \
    python-sip \
    python-sgmlop \
    python-soappy \
    python-spydi \
    python-sqlalchemy \
    python-sqlobject \
    python-tlslite \
    python-twisted \
    python-vorbis \
    python-webpy \
    task-python-efl \
"
