require inetlib_${PV}.bb

inherit native
