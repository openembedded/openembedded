require libtasn1_${PV}.bb

inherit native

