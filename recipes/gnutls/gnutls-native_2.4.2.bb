require gnutls_${PV}.bb

inherit native

