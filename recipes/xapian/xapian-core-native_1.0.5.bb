require xapian-core_${PV}.bb

inherit native

S = "${WORKDIR}/xapian-core-${PV}"

SRC_URI[md5sum] = "5fbfec7f23b0f539d32b50de4a278b95"
SRC_URI[sha256sum] = "277e30cbd4a4d9355e9b2c02489d34cbaed87754bbdeb8956e5463e9fb592658"
