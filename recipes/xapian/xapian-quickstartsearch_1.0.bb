require xapian-quickstart.inc

DESCRIPTION += "This package provides the tool for searching the index."
PR = "r1"

SRC_URI[md5sum] = "9874bb8924b9ffcfb82ffdfb9bac94d1"
SRC_URI[sha256sum] = "643bcc948b53b2f2a72fc1698574e1004831784467f660b0da9955db0b392f1d"
