include xapian-core.inc

SRC_URI[md5sum] = "5442e7ffc75abd853d1ab1d12667a3e9"
SRC_URI[sha256sum] = "a474be06657bd83200231d938d48d4d2a83cff0252c618421f835604c5548dce"
