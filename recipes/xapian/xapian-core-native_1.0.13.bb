require xapian-core_${PV}.bb

inherit native

S = "${WORKDIR}/xapian-core-${PV}"

