PR = "${INC_PR}.0"
require whois.inc

SRC_URI[whois.md5sum] = "0a045c041a58ca8e8449c9f96fba47e0"
SRC_URI[whois.sha256sum] = "53fedf5dfbe49990324bc8afd6013d43702b6c7d45cdd2adb4201c526996ed96"

