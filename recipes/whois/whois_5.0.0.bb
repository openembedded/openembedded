require whois.inc
PR = "${INC_PR}.0"

SRC_URI[whois.md5sum] = "18d74a07d711262b75f04a1c319bc833"
SRC_URI[whois.sha256sum] = "fb13316c09ff9f98bd9af659d0789c9a09b97757f5c6c3dbfbc790250d5c5abc"

