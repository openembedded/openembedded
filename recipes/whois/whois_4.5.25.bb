PR = "${INC_PR}.0"
require whois.inc

SRC_URI[whois.md5sum] = "516fc54ce709e874133fc3b3c7c05447"
SRC_URI[whois.sha256sum] = "99979ff161ee209da21ae118eff9ca6de7c5cb1b0dc3397de18df534e0afaf76"
