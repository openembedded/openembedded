require libv4l.inc

SRC_URI[libv4l.md5sum] = "4f8ae9c743b215c8ac0e553eaa01e980"
SRC_URI[libv4l.sha256sum] = "9d006377ec51ca149ed415fbea5c3298b0fe7bae4cbd3bc2f54fd25a24ed9eb2"
