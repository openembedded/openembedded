require libv4l.inc

SRC_URI[libv4l.md5sum] = "0d0d96d77c98871d2e5466c10cb30a0a"
SRC_URI[libv4l.sha256sum] = "36b93e192cd0d16d764370d0c5917a5d8257eefbaada48ba379736bdd3f22bbf"
