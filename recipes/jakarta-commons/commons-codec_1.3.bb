require jakarta-commons.inc

DESCRIPTION = "Java library with simple encoder and decoders for various formats such as Base64 and Hexadecimal"

SRC_URI = "http://www.apache.org/dist/commons/codec/source/${BP}-src.tar.gz"

S = "${WORKDIR}/${BP}"
