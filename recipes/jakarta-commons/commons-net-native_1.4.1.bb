require commons-net_${PV}.bb

inherit java-native 

DEPENDS = "fastjar-native oro-native"
RDEPENDS = ""

