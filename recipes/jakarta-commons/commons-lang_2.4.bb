require jakarta-commons.inc

DESCRIPTION = "Set of Java classes that provide helper methods for the standard java.lang classes"

SRC_URI = "http://www.apache.org/dist/commons/lang/source/${BP}-src.tar.gz"

