require jakarta-commons.inc

DESCRIPTION = "Java Object-pooling API"

SRC_URI = "http://www.apache.org/dist/commons/pool/source/${BP}-src.tar.gz"
