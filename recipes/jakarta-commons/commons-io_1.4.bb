require jakarta-commons.inc

DESCRIPTION = "Java library with utility classes, stream implementations, file filters and endian classes"

SRC_URI = "http://www.apache.org/dist/commons/io/source/${BP}-src.tar.gz"
