require jakarta-commons.inc

DESCRIPTION = "A set of abstract data type interfaces and implementations that offer a wealth of useful functionality and a solid foundation for extending that functionality"

SRC_URI = "http://www.apache.org/dist/commons/collections/source/${BP}-src.tar.gz"


SRC_URI[md5sum] = "3fc2e8f9d0647074cba992b534ecf6df"
SRC_URI[sha256sum] = "73eb5907a31c8770480c70f6a6a8d9a9a2ffe602e1b461c045cff51ace4cab2a"
