require jakarta-commons.inc

DESCRIPTION = "Java argument parsing helper classes"

SRC_URI = "http://www.apache.org/dist/commons/cli/source/${BP}-src.tar.gz"


