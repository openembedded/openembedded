require commons-logging_${PV}.bb

inherit java-native

DEPENDS = "fastjar-native log4j1.2-native servlet2.3-native logkit-native"

