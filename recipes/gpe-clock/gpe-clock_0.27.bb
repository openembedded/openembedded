require gpe-clock.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "93fcd53df14e2005edbadeb128d0a274"
SRC_URI[sha256sum] = "c4c8a6d759e06ce9fd339ccd75479c8b62c9da434c4bb1246832419e5068e1df"
