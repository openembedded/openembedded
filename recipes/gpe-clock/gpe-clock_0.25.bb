require gpe-clock.inc

PR = "${INC_PR}.0"

SRC_URI += "file://fix-install.patch;patch=1"

SRC_URI[md5sum] = "75e087fcf8345cf1bfde7e172844e949"
SRC_URI[sha256sum] = "0070e1c622f3f0cf9c40556f551de3e6059c7f8b3070516c0e4173dd09f57759"
