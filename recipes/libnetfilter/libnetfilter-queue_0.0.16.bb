include libnetfilter-queue.inc


SRC_URI[md5sum] = "b36664e6cd39edbfe46b416a86118add"
SRC_URI[sha256sum] = "977491a20928cd40fa91a51b99c625fe0aa7efb47d4207a551b5f2f5e5e4c391"
