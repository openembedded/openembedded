include libnetfilter-queue.inc


SRC_URI[md5sum] = "660cbfd3dc8c10bf9b1803cd2b688256"
SRC_URI[sha256sum] = "1d6b180272befbfb19fedd80b5641354b82d6e719bf3d9ffa2d8287c62046536"
