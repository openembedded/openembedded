require nzbget.inc
PR = "${INC_PR}.0"

