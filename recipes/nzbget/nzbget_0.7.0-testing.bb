require nzbget.inc
PV = "0.6.9+0.7.0r342"
SRC_URI = "${SOURCEFORGE_MIRROR}/nzbget/nzbget-stable/nzbget-0.7.0-testing-r342.tar.gz"
S = "${WORKDIR}/nzbget-0.7.0-testing"

