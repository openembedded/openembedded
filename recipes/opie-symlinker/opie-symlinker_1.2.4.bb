require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_core_symlinker.tar.bz2;name=split_core_symlinker"
SRC_URI[split_core_symlinker.md5sum] = "ec7ae583607c39bf90f5da0be1a481bf"
SRC_URI[split_core_symlinker.sha256sum] = "56f0f08459e27acc37a0420468bea114c24b288362f13909d8b31c68c367b89f"
