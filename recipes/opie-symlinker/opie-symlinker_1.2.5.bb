require ${PN}.inc

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_core_symlinker.tar.bz2"
