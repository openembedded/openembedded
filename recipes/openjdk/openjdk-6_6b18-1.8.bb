require openjdk-6-release-6b18.inc

PR = "${INC_PR}.8"
