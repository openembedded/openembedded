require ${PN}.inc
PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_core_multimedia_opieplayer.tar.bz2 \
	   file://libmadplugin.pro"
