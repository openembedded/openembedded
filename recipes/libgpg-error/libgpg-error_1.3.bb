require libgpg-error.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "aae34a35b00c547f2e41c747cf87f8b7"
SRC_URI[sha256sum] = "d815a1a5445fc26de5c7b10192acb77cf4277a100124842b616f85a5a4fbfe3b"
