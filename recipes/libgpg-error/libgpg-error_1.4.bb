require libgpg-error.inc

PR = "${INC_PR}.1"
