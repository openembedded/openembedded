require libgpg-error.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "ff409db977e4a4897aa09ea420a28a2f"
SRC_URI[sha256sum] = "7baf0a33a717c5d5b24faf592ba16fc5e962f1537f46b11f6ed003010a8ff1e9"
