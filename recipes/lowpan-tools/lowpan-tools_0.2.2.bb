require lowpan-tools.inc

PR = "${INC_PR}.0"

EXTRA_OECONF = "--enable-ip-plugin"

SRC_URI[md5sum] = "c727b36e5a6053b15e54ecf220bd5d6b"
SRC_URI[sha256sum] = "6e3f70290caec98fb22254f008eb24b4b8820cc9b10d1e1f6e78d160d2aa8905"
