require lowpan-tools.inc

PR = "${INC_PR}.0"

EXTRA_OECONF = "--enable-ip-plugin"

SRC_URI[md5sum] = "e2fa536e8b6402a88fcb98fe3296fe46"
SRC_URI[sha256sum] = "f72dd915503803b02104abfd29a4b00216af471c11b2aec44c51b9cf4c5e618b"
