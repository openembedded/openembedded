# p4 .bb build file
# Copyright (C) 2006, Advanced Micro Devices, Inc.  All Rights Reserved
# Released under the MIT license (see /COPYING)

require p4.inc

SRC_URI[p4.md5sum] = "9bc57695db5885ffac0a352fc17a7f84"
SRC_URI[p4.sha256sum] = "56dd1cb2364b8c8618f9019b641d17d6b307a5a797f3ac31c16a01247554e10c"
SRC_URI[p4api.md5sum] = "7bdb4d9f59a231cc90a8e93709ec1595"
SRC_URI[p4api.sha256sum] = "2e742bf3358f9b8b38f692f4222f96d6901a6faedca155942f58435cee385614"
SRC_URI[p4d.md5sum] = "9a72849bb39cfe19da018271824a3ae1"
SRC_URI[p4d.sha256sum] = "d67bc483b3cbccdcf32db6af21f02d20793a4c3ccc4b758c3a66374b410b73e8"
SRC_URI[p4ftpd.md5sum] = "eb47a4e532fca795893f0c727ae59c84"
SRC_URI[p4ftpd.sha256sum] = "bb5de57d0098e1c6f0d238cc4e658c64579b26fc1df58b9ce59c057fcb5b2f4c"
SRC_URI[p4p.md5sum] = "eed70a3a6af7e59a44d614d4a8022ff0"
SRC_URI[p4p.sha256sum] = "b4b6546d16f161a50337bf9f5dfaf3a4795a3c9b56931e7ee2ace8bcf1863d6e"
SRC_URI[p4web.md5sum] = "e97b15e64be5a3773880f7d66e87a541"
SRC_URI[p4web.sha256sum] = "ce72ef785a92aa8c71b6525e37da49bebab670a046b2ee0c023713f5aa497826"
