# p4 .bb build file
# Copyright (C) 2006, Advanced Micro Devices, Inc.  All Rights Reserved
# Released under the MIT license (see /COPYING)

require p4.inc

SRC_URI[p4.md5sum] = "ba983759366018ad2d90a7e088f509eb"
SRC_URI[p4.sha256sum] = "de8bce2b3ae085a973dca4f7208c3cb1ab1fdc9bbcc9e3496ad3d56a4923dba0"
SRC_URI[p4api.md5sum] = "1eb1fb53531e09a03f158957016d55a6"
SRC_URI[p4api.sha256sum] = "7d5455c9aa77aea548f3b52f579bf41fff034f0be1c283840b88be401f817792"
SRC_URI[p4d.md5sum] = "690a404af3d916dc7c1cfa5a14a51171"
SRC_URI[p4d.sha256sum] = "e41d44dbc5bd60f2140f0774945154105759b2dabf4c26c097cf754797274e39"
SRC_URI[p4ftpd.md5sum] = "c099df674fb3c249cb1d1984f00d573e"
SRC_URI[p4ftpd.sha256sum] = "9839564335035bc92041fafd93d05a811dc4243bb72269b3afe5ba823f016418"
SRC_URI[p4p.md5sum] = "02de68f26da402689f661662217cd77f"
SRC_URI[p4p.sha256sum] = "24d153529f669ff5fd9dc0d7a09bf7c6e658ee2d2496ab8025a2aaf12425907c"
SRC_URI[p4web.md5sum] = "7bf9967719351c7a0758e20641978358"
SRC_URI[p4web.sha256sum] = "70ebe07343989de042b9ef7866cfca540cfb28458e6c475d516c6916f4feb468"
