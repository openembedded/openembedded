require postgresql.inc

PR = "r4"

SRC_URI[md5sum] = "a65bdc5d833169d28bf6fbaaa8d57fcf"
SRC_URI[sha256sum] = "ac7e7d311b07abd27b084041bcc943398df303bc86601f281891537bdf1a4e0b"
