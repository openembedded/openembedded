require ${PN}.inc

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_noncore_applets_wirelessapplet.tar.bz2;name=split_noncore_applets_wirelessapplet"
SRC_URI[split_noncore_applets_wirelessapplet.md5sum] = "46874074feb45aa6179250ce39d8f6c6"
SRC_URI[split_noncore_applets_wirelessapplet.sha256sum] = "dcbb5e1e1462d5ced16575cbc1f3d082931dd48b3bb2062c0729f6ac718a1448"
