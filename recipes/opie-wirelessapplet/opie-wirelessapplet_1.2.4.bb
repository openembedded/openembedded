require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_noncore_applets_wirelessapplet.tar.bz2;name=split_noncore_applets_wirelessapplet"
SRC_URI[split_noncore_applets_wirelessapplet.md5sum] = "e72deac125899069b71357c1379ffde3"
SRC_URI[split_noncore_applets_wirelessapplet.sha256sum] = "6573b2a055564f760e499e541d898b4509e3a853cd3826b64d77b67cc64b7de2"
