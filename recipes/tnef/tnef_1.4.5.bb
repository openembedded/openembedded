require tnef.inc

PR = "r0"

SRC_URI[md5sum] = "ec46d47525c6afb928642e3edec21058"
SRC_URI[sha256sum] = "42067fbc00d1ad4bcbb67440d61869aa43ed2d3d099fc691d3da8ad4296fa6b1"
