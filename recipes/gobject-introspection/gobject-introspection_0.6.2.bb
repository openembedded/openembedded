require gobject-introspection.inc
PR = "r0"
DEPENDS = "glib-2.0 bison flex python-dev libffi"
