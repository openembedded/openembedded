require jfsutils.inc

SRC_URI = "cvs://anonymous@jfs.cvs.sourceforge.net/cvsroot/jfs;module=jfsutils"
S = "${WORKDIR}/${PN}"

DEFAULT_PREFERENCE = "-1" 
