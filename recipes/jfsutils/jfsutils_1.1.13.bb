require jfsutils.inc

 

SRC_URI[md5sum] = "14ad3a2eb26e55ef34ac0569f5739ccc"
SRC_URI[sha256sum] = "668ac8bbef3c153efa9bdaaea3228de93142e7e1cff6b8793b0c8970a62ad2ec"
