require upslug2.inc
