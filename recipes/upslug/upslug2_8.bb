require upslug2.inc

SRC_URI[md5sum] = "c7e9c64afa7a375a523a250f9fd778a9"
SRC_URI[sha256sum] = "b0b5302ce0d17efb0d2a8ba92273524cbe8f96ebd5ae21475c905922806d445a"
