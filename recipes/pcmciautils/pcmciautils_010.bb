require pcmciautils.inc

PR = "r3"

CFLAGS =+ '-DPCMCIAUTILS_VERSION=010'

SRC_URI[md5sum] = "ff3cb012fd1a8801e912054b45420ac2"
SRC_URI[sha256sum] = "9ed7fe56197b4e1328a94842b602aef0a3a2e3380dacc95b4366661582e05661"
