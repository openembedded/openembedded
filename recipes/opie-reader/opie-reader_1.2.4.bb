require ${PN}.inc

PR = "${INC_PR}.1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_noncore_apps_opie-reader.tar.bz2 \
           http://sources.openembedded.org/opie-1.2.4-split_pics.tar.bz2 \
           http://sources.openembedded.org/opie-1.2.4-split_apps.tar.bz2"
