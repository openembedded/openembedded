require ${BPN}.inc

PR = "r1"
SRC_URI += " file://slice2ccp-no-crash.patch "

SRC_URI[md5sum] = "512de48c87ab023a69250edc7a0c7b05"
SRC_URI[sha256sum] = "3b9b4421888519876c4fc68ade324a3bbd81ceeb7092ecdbbc2055099fcb8864"

