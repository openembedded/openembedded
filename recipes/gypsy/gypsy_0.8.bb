require gypsy.inc

PR = "${INC_PR}.0"

SRC_URI[gypsy.md5sum] = "32b8db24db86d2dac87b391dd255f4bf"
SRC_URI[gypsy.sha256sum] = "1986a58189614a950725c3bc7d05faa3b84695f35cb696326f340ef87fc3acaa"
