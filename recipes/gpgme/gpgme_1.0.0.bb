require gpgme.inc

PR = "r3"

SRC_URI[md5sum] = "1abf7accd905c435da567d0852c080af"
SRC_URI[sha256sum] = "685e0162af08d90e01251a02c2f916de59b2b4fa903e9a3a119208b6bcca6092"
