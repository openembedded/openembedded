require gpgme.inc

PR = "r5"
