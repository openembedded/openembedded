require gpgme.inc

PR = "r3"

SRC_URI[md5sum] = "4d33cbdf844fcee1c724e4cf2a32dd11"
SRC_URI[sha256sum] = "376796ba50ee251af63c1fe2aa17603aaac04b64527ba3bc89e4fa023322282f"
