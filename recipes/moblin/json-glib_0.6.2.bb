
SRC_URI = "http://folks.o-hand.com/~ebassi/sources/json-glib-0.6.2.tar.gz"
PR = "r0"

DEPENDS = "glib-2.0"

inherit autotools_stage

SRC_URI[md5sum] = "d98f5580035ad0b37fa11896053a57af"
SRC_URI[sha256sum] = "7befca7f7d7d65cbb260eacd86eff2c1dcae8d859ae2c3e3002e2536d02b2c49"
