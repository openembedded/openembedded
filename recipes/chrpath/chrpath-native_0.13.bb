require chrpath.inc

inherit native

SRC_URI[md5sum] = "b73072a8fbba277558c50364b65bb407"
SRC_URI[sha256sum] = "c1aa5342eac0daad81b8da05aa282ae1ccd6f68bc75ca94064304f541eed071b"
