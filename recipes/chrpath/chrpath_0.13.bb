require chrpath.inc
