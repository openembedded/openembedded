require glibmm.inc

SRC_URI[archive.md5sum] = "3d0f763e408a71700090fff4d3dd110c"
SRC_URI[archive.sha256sum] = "5fb1f4f68625811a70fb580b945c2f93925569591af5444eb074aed6956366ca"
