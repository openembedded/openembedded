require glibmm.inc

SRC_URI[archive.md5sum] = "408054366f0acc01014f4c4af2304da5"
SRC_URI[archive.sha256sum] = "f033f6f39c32fc17ecce63087e41408671a3a43d698c83de2528af3fc7276d28"
