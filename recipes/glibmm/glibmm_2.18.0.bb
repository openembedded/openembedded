require glibmm.inc

SRC_URI[archive.md5sum] = "1a0df362e15e7f850b8361b5102f1f16"
SRC_URI[archive.sha256sum] = "ca6c46b87748cabd61e7d5ef892f09f433eaea324e63637f7de1f0217465cd31"
