require postfix.inc

PR = "${INC_PR}.0"

SRC_URI[postfix-2.0.20.md5sum] = "92479b64d132262be505a17ec02bc2a8"
SRC_URI[postfix-2.0.20.sha256sum] = "78c03b41d75f7402a63a5e5e13f3690005411a85299bc6ec9edbe04888db6d18"
