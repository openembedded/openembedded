require postfix.inc

PR = "${INC_PR}.0"
SRC_URI[postfix-2.2.12.md5sum] = "e73299c07407da60a53c0cf089b4abe8"
SRC_URI[postfix-2.2.12.sha256sum] = "a736ed4936ad20c2b012fde699a033360c38ae6201ebb8a98d3bfaca6737d4b3"
