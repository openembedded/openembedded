require postfix.inc

SRC_URI[postfix-2.7.0.md5sum] = "df648f59421604e895cce56325f00bae"
SRC_URI[postfix-2.7.0.sha256sum] = "c5b232ae5e396107bc58aed4178cf6cfd0a75b9dcbbedb49d158eb71d6c91b75"

PR = "${INC_PR}.0"