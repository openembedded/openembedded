require ed.inc

LICENSE = "GPLv3+"
PR = "${INC_PR}.0"

SRC_URI = "${GNU_MIRROR}/ed/ed-${PV}.tar.gz"
SRC_URI[md5sum] = "e66c03d7e4c67b025d5b6093ec678267"
SRC_URI[sha256sum] = "97dd34a49ebc9c97e414b90a087d63eafc41377a340848c97e75a9cba187fba1"
