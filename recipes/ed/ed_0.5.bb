require ed.inc

LICENSE = "GPLv2+"
PR = "${INC_PR}.0"

SRC_URI = "${SAVANNAH_MIRROR}/releases/ed/ed-${PV}.tar.bz2"
SRC_URI[md5sum] = "4ee21e9dcc9b5b6012c23038734e1632"
SRC_URI[sha256sum] = "edef2bbde0fbf0d88232782a0eded323f483a0519d6fde9a3b1809056fd35f3e"
