require opie-securityplugin-notice.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_noncore_securityplugins_notice.tar.bz2 \
           http://sources.openembedded.org/opie-1.2.4-split_pics.tar.bz2"

