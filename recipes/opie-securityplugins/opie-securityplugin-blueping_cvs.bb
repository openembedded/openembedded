require opie-securityplugin-blueping.inc

PV = "${OPIE_GIT_PV}"

SRC_URI = "${OPIE_GIT};protocol=git;subpath=noncore/securityplugins/blueping \
           ${OPIE_GIT};protocol=git;subpath=pics "

