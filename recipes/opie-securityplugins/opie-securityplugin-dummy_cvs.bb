require opie-securityplugin-dummy.inc

PV = "${OPIE_GIT_PV}"

SRC_URI = "${OPIE_GIT};protocol=git;subpath=noncore/securityplugins/dummy \
           ${OPIE_GIT};protocol=git;subpath=pics "

