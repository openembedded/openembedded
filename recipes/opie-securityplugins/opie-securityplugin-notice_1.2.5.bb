require opie-securityplugin-notice.inc

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_noncore_securityplugins_notice.tar.bz2 \
           http://sources.openembedded.org/opie-1.2.5-split_pics.tar.bz2"

