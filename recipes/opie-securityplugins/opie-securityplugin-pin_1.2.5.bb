require opie-securityplugin-pin.inc

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_noncore_securityplugins_pin.tar.bz2 \
           http://sources.openembedded.org/opie-1.2.5-split_pics.tar.bz2"

