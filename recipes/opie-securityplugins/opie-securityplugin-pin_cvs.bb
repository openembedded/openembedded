require opie-securityplugin-pin.inc

PV = "${OPIE_GIT_PV}"

SRC_URI = "${OPIE_GIT};protocol=git;subpath=noncore/securityplugins/pin \
           ${OPIE_GIT};protocol=git;subpath=pics "

