require opie-securityplugin-notice.inc

PV = "${OPIE_GIT_PV}"

SRC_URI = "${OPIE_GIT};protocol=git;subpath=noncore/securityplugins/notice \
           ${OPIE_GIT};protocol=git;subpath=pics "

