require kde4.inc

DEPENDS += "automoc-native"

PV = "1.0"
SRC_URI = "svn://anonsvn.kde.org/home/kde/branches/akonadi;module=1.0;proto=svn"

S= "${WORKDIR}/1.0"

