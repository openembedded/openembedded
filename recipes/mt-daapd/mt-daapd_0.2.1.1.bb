require ${PN}.inc
PR = "r4"
SRC_URI += "file://itunes-5-fix.patch;patch=1"

SRC_URI[md5sum] = "87356d2750ad82388a58d901aa566465"
SRC_URI[sha256sum] = "92d9abd2d0cabaea198b9434100ebf1d5524283de8df02b0f04d907b2274959b"
