require ${PN}.inc

PR = "r0"

SRC_URI[md5sum] = "67bef9fb14d487693b0dfb792c3f1b05"
SRC_URI[sha256sum] = "50d89f77bdc3fd0ca408d52cabff528224fcc7319acc3b9456db0e3164a3b6cf"
