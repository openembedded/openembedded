require ${PN}.inc
# This has not been released yet!
DEFAULT_PREFERENCE = "-1"
PR = "r1"

SRC_URI[md5sum] = "e5aee70f66d383f37ef650941cd7703d"
SRC_URI[sha256sum] = "5e06d8ed89ba98092c2cda16ecd9cdfeaa08b6c0e77ac459f49ae6e5dd64d639"
