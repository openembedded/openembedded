require ${PN}.inc
# This has not been released yet!
#DEFAULT_PREFERENCE = -1
PR = "r1"

SRC_URI[md5sum] = "17aa3fa0601cbe172d18f53489141e5a"
SRC_URI[sha256sum] = "17e3966a9da7acb0560af1d2c1a5c0162da8e01de195aa096d594ab6248c4930"
