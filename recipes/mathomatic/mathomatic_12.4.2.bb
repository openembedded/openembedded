require mathomatic.inc

SRC_URI = "http://www.panix.com/~gesslein/mathomatic-${PV}.tgz"
SRC_URI[md5sum] = "ad0df739c64a3db1733f2e290b0549ae"
SRC_URI[sha256sum] = "cf04ec6b5d16ab70335a08aef483ff357ed454fd7b972f1c424ce0855973cee3"
