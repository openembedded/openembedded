# fdisk gets a #error unknown architecture when compiling for ARM thumb
#FIXME: remove this
ARM_INSTRUCTION_SET = "arm"

require util-linux.inc

PR = "r7"

SRC_URI[md5sum] = "54320aa1abbce00c0dc030e2c3afe5d7"
SRC_URI[sha256sum] = "2e68a53d1393e97926340d9b21e1bde488aaef05ab3e8bcab4849d1859115c6d"
