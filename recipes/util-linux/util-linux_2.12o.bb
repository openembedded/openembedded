require util-linux.inc

PR = "r8"

SRC_URI[md5sum] = "a7c0c2729ed27beac39cf656d2097dd3"
SRC_URI[sha256sum] = "913a83f69a370b6ee858577f8f1d218cfe899fd39d7b8a380df4971b6059e8e0"
