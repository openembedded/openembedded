require gpe-su.inc

PR = "r1"

SRC_URI[md5sum] = "7e22069a6c59138f8b6e3f9cbc6bb616"
SRC_URI[sha256sum] = "bf1df54e88dbfa94be7b9f9a4c897635dca1ec56885352d8ebeac99f747b0554"
