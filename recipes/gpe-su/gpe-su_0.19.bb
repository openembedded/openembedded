require gpe-su.inc

PR = "r1"

SRC_URI[md5sum] = "1225673cf9cc1671a031f0eb2b57b3f9"
SRC_URI[sha256sum] = "b0a7db0fceeda65b88bb8abd8743afb9bf0d5674ed3fe6444439c0dad90da27b"
