require gpe-su.inc

PR = "r0"

SRC_URI[md5sum] = "157cb20e41953d2148193d7e3eab173a"
SRC_URI[sha256sum] = "b5e3917a2a2fb1cbce5cc724cd4c6f523c84890b7f97d520808122cf04e89139"
