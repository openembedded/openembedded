require hostap-modules.inc
PR = "r7"

SRC_URI += "file://kernel_updates.patch;patch=1"

SRC_URI[md5sum] = "e9b4a5cb992e06c3c6bf2bc99eca6625"
SRC_URI[sha256sum] = "7b9ad6bb5cf6c485e320bd8901d2e398cb6661cda633ba6360200a9bf94eb5fb"
