require hostap-modules.inc
PR = "r5"

SRC_URI += "file://kernel_updates.patch;patch=1"

SRC_URI[md5sum] = "ee495686cf27011b4e401963c2c7f62a"
SRC_URI[sha256sum] = "e9a3e035a1483b371269936c6fde46bfbae71dc38fa04685c1338ca8ffe900a5"
