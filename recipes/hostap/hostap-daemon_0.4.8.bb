require hostap-daemon.inc

PR = "r1"

DEFAULT_PREFERENCE = "-1"

SRC_URI[md5sum] = "b8f30f23c04b74f18b2e4e6d8e0ee014"
SRC_URI[sha256sum] = "4675ae608a9f16e0ac519af2003ef694e7e13a4ecda2fcbe29f12a306e460551"
