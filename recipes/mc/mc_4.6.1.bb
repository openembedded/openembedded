require mc.inc
PR = "r3"

SRC_URI[md5sum] = "18b20db6e40480a53bac2870c56fc3c4"
SRC_URI[sha256sum] = "086ab03daaac28a28c0ddb9a709040b59e1322f6bfa68e39d004d9c66b119e7e"
