require libgpepimc.inc

SRC_URI[md5sum] = "bbb0efe3359510fc0393f3f305c1c6e7"
SRC_URI[sha256sum] = "b0d1236dbb27f054f8b8a6f8ed4d735db89eb466be641bed67363f4dd76385ad"
