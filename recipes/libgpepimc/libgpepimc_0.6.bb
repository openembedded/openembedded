require libgpepimc.inc

SRC_URI[md5sum] = "3e5ffa6c4e556c5ccc8ec8f53a27eb69"
SRC_URI[sha256sum] = "71c7d6ab2ca142f100241d5256c58b67ac01a3d34d52722178e4da9d6ac0729f"
