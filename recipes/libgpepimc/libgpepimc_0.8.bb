require libgpepimc.inc

SRC_URI[md5sum] = "308f75a47ab738cb2955f8a8051728e5"
SRC_URI[sha256sum] = "b914f2cf05353e2f4471648b37782a82d73ebf895a50ab1e238e3a325cce2c65"
