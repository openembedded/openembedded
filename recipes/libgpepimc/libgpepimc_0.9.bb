require libgpepimc.inc
PR = "r1"

SRC_URI += " file://get-category-by-name.patch;patch=1"

SRC_URI[md5sum] = "0d22564e0a897b3be2eb9d2fc71fbd65"
SRC_URI[sha256sum] = "8954f7179d2172f8d561d42209e25027a1eece832e35986d9637c404c1a3add0"
