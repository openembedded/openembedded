include gsl.inc

SRC_URI = "${GNU_MIRROR}/gsl/gsl-${PV}.tar.gz"

SRC_URI[md5sum] = "d67be4f2e5560d6cf907e18a428becdc"
SRC_URI[sha256sum] = "ea3968b58bfc7619f47bf5ff64a7198a38c72419d24b844e71e48823a4776ff0"
