require libhildonmime.inc

PR = "r0"

SRC_URI = "http://archive.ubuntu.com/ubuntu/pool/universe/libh/libhildonmime/libhildonmime_${PV}-1ubuntu1.tar.gz"


SRC_URI[md5sum] = "2320b71819d44dc40a974cb67084f2a7"
SRC_URI[sha256sum] = "6815f0a46de672711866b031c09ed8a94e1cbbe193c6a6b5cb72286ff90cfe54"
