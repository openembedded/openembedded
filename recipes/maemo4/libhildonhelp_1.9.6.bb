require libhildonhelp.inc

PR = "r0"

SRC_URI = "http://repository.maemo.org/pool/maemo4.0/free/source/libh/${PN}/${PN}_${PV}-1.tar.gz"


SRC_URI[md5sum] = "6f3328136f1b8dabf667d954b0698189"
SRC_URI[sha256sum] = "b2219de48715579d589705cb7b88af8d3dd3cf18de0fd3d799241720b2384bdf"
