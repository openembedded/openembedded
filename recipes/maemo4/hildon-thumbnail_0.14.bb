require hildon-thumbnail.inc

DEPENDS = "libosso gnome-vfs gconf gtk+ glib-2.0"

PR = "r1"

SRC_URI = "http://repository.maemo.org/pool/maemo4.0/free/source/h/${PN}/${PN}_${PV}.tar.gz \
          "
