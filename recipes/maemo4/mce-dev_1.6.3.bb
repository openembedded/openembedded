require mce-dev.inc

PR = "r0"

SRC_URI = "http://repository.maemo.org/pool/maemo4.0/free/source/m/mce-dev/mce-dev_${PV}.tar.gz"



SRC_URI[md5sum] = "c3e128f6b99a00d5ef029b52af236453"
SRC_URI[sha256sum] = "f6ea98fb44e978966d41bf5ad7f662df33dd0ef236403753bfbbea93a1c34701"
