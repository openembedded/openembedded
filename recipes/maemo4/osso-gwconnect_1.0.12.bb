require osso-gwconnect.inc

DEPENDS += "libhildon bluez-libs"

PR = "r0"

SRC_URI = "http://repository.maemo.org/pool/maemo4.0/free/source/o/${PN}/${PN}_${PV}.tar.gz"


SRC_URI[md5sum] = "067de342f812811e6585b58049895168"
SRC_URI[sha256sum] = "015b5b318c74650d1e85319ee05e8c506dd7a30daf280d7c1e23b914c1e4c7f8"
