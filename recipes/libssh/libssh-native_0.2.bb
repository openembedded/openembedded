require libssh_${PV}.bb
inherit native
DEPENDS = ""

