require yasm.inc

inherit native

