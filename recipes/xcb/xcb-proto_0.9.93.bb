include xcb-proto.inc
PR = "r0"

SRC_URI[md5sum] = "43298a907d6d242132c20e4338c2f33f"
SRC_URI[sha256sum] = "3f28eb14edd588878d39a33803adc0d3cc49e9dfaef77d9db0490125b3da786e"
