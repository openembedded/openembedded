include libxcb.inc
PR = "r0"

SRC_URI[md5sum] = "6f01c8fa200deebb20b019f7401a2606"
SRC_URI[sha256sum] = "64337d31564f3239ccb8f0d7f8e1c4987f570985af3ab83a38cf9af5736ef9b1"
