require libpthread-stubs.inc
PR = "${INC_PR}.0"

# For unknown reason doesn't create libpthread-stubs.la
DEFAULT_PREFERENCE = "-1"

SRC_URI[md5sum] = "e8fa31b42e13f87e8f5a7a2b731db7ee"
SRC_URI[sha256sum] = "35b6d54e3cc6f3ba28061da81af64b9a92b7b757319098172488a660e3d87299"
