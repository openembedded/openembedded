include xcb-proto.inc
PR = "r0"

SRC_URI[md5sum] = "d31407eaae7e52d100645217767a41aa"
SRC_URI[sha256sum] = "df3ce807139957a9d3bd196a6eb5fad1d04af079d47b0ec36502911520b84e08"
