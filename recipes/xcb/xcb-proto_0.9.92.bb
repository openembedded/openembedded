include xcb-proto.inc
PR = "r0"

SRC_URI[md5sum] = "dc05c33ae1efc3e59d725887de9fc1a6"
SRC_URI[sha256sum] = "4590e383f9bb6cc724e2033911a96d36f5966a5f82771bd3f06a63add2aa3e10"
