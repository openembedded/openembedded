include xcb-proto.bb
PR = "${INC_PR}.0"
