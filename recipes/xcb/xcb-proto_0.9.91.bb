include xcb-proto.inc
PR = "r0"

SRC_URI[md5sum] = "830cac0c81e43807849dd172bf7e65e2"
SRC_URI[sha256sum] = "cefb1a052f8366d1ddfaabc9dc4207307855ab2b12862989fa3cbec02a48f1fa"
