include libxcb.inc
PR = "r0"

DEPENDS += "libpthread-stubs"

PACKAGES =+ "libxcb-xinerama"

SRC_URI[md5sum] = "0eb951fd0fa9542dbe4fc3530b81a3b6"
SRC_URI[sha256sum] = "19d6b2ac380fd3e613a3730e791f197f186f940bffec97f8a4f9443bb727d11d"
