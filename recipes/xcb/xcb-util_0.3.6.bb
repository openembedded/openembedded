include xcb-util.inc
PR = "r0"

SRC_URI[md5sum] = "dd8968b8ee613cb027a8ef1fcbdc8fc9"
SRC_URI[sha256sum] = "ffb8ee11ab015858a970ab7edd56bd2436b281657596561d8429d4a90df60e57"
