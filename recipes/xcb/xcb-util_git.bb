DEFAULT_PREFERENCE = "-1"

include xcb-util.inc
SRCREV = "962145e957ca283603f55c01fddb505be10583f4"
PV = "0.3.6+git"
PR = "r0"

SRC_URI = "git://anongit.freedesktop.org/xcb/util;protocol=git"
S = "${WORKDIR}/git"
