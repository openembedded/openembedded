include libxcb.inc
PR = "r0"

SRC_URI[md5sum] = "8bb01876468dd08d8e921e32ec9ff116"
SRC_URI[sha256sum] = "a54ecc4ff5240876d49ec534a21e6ff682f3602da89b1540f5cd0b6f8e9089b7"
