include xcb-util.inc
PR = "r0"

SRC_URI[md5sum] = "b09bdebad50638709de22d8eb2dc3bf5"
SRC_URI[sha256sum] = "a0d6a15ac4dcbcea832f2f9b2dbcf575b02cf69aa92f0ba90bd35b61cd75b01a"
