include libxcb.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "7967d0d4347502bc9af5373767afc748"
SRC_URI[sha256sum] = "106b3747c3c49c2940973b18b487c604a5dffc8995fb02a4c46136d6ff267122"
