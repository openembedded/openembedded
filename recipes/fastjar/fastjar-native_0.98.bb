require fastjar-native.inc

PR = "${INC_PR}.1"
