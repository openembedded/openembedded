require fastjar.inc
