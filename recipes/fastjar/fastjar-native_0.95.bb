require fastjar.inc
require fastjar-native.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "92a70f9e56223b653bce0f58f90cf950"
SRC_URI[sha256sum] = "ca03811490c965abc9f466e75418ae48bb71f14d8e8ed4c43e8109207b85ce54"
