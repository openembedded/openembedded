require mpfr_svn.bb
inherit native
DEPENDS = "gmp-native"
