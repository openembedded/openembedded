require mpfr_${PV}.bb
inherit native
DEPENDS = "gmp-native"


SRC_URI[md5sum] = "8352b619e04dcc73411a38b39dd855f6"
SRC_URI[sha256sum] = "d857f9df4a6cf50d0bc57dd11296dd1a8d1ac709442875ea4fcd757a89da8430"
