require mpfr_${PV}.bb
inherit native
DEPENDS = "gmp-native"

SRC_URI[md5sum] = "527147c097874340cb9cee0579dacf3b"
SRC_URI[sha256sum] = "18e078c996e182b7ceab32f2ab840e6a151b593e0cd5b83cb9d2960f212fba4c"
