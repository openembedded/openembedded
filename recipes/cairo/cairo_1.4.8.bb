require cairo.inc

SRC_URI = "http://cairographics.org/releases/cairo-${PV}.tar.gz"

PR = "r0"


SRC_URI[md5sum] = "5b9db574c9fbb94ce52047600190a1ba"
SRC_URI[sha256sum] = "a3e9b0f07910ee325406118cf3e136fc78a5155c47fdb19e66e895a3c587bc51"
