require cairo.inc

DEPENDS = "cairo"
DESCRIPTION = "C++ bindings for Cairo graphics library"

SRC_URI = "http://cairographics.org/releases/cairomm-${PV}.tar.gz"

