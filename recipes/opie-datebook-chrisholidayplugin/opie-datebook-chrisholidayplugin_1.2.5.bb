require ${PN}.inc

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_core_pim_datebook_plugins_christian.tar.bz2;name=split_core_pim_datebook_plugins_christian"
SRC_URI[split_core_pim_datebook_plugins_christian.md5sum] = "79c4bcc4d1c0224e0015f064f7f74472"
SRC_URI[split_core_pim_datebook_plugins_christian.sha256sum] = "98dafab30d02d34a0dd70dae59a3ad2262e45d272dfab476bfaac23f8868e23e"
