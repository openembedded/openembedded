require centerim.inc

PR = "r0"

SRC_URI[md5sum] = "9bbbdb34ab678d29387171139ae835e1"
SRC_URI[sha256sum] = "c68abb59043602a2b28fb55d45361d0b22fc1566848cc0c255580914df7b3eb3"
