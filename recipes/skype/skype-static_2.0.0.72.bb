include skype_${PV}.bb

SRC_URI = "http://download.skype.com/linux/skype_static-2.0.0.72.tar.bz2"
S="${WORKDIR}/skype_static-${PV}"
