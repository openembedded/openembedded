require gpe-todo.inc

DEPENDS += "gtk+ libgpepimc"

SRC_URI[md5sum] = "149ba7a31c7a7855146faa8f321d7cca"
SRC_URI[sha256sum] = "b8304c9f69922b30064a4e8637576034fe0be3a4b699a04968e1b1f899974df1"
