require gpe-todo.inc

DEPENDS += "gtk+ libgpepimc"

SRC_URI[md5sum] = "d60eda0b82431bc4dd92cf7c40c0efe9"
SRC_URI[sha256sum] = "85124fe55ecd1ad303a3a333b9d8501deb627beeca85bfb6f66832389bc73f49"
