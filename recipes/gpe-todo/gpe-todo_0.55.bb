require gpe-todo.inc

DEPENDS += "gtk+"

SRC_URI[md5sum] = "e8c08165d9723779473e3390a949afac"
SRC_URI[sha256sum] = "ec2ef95c967acce5834c8b4985c610014c16242d223d233947d67b4514ebe298"
