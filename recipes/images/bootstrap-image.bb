DEPENDS = "${MACHINE_TASK_PROVIDER}"

IMAGE_LINGUAS = ""
IMAGE_INSTALL = "${MACHINE_TASK_PROVIDER}"

inherit image

