require console-image.bb
IMAGE_INSTALL += "task-sdk-native"
export IMAGE_BASENAME = "native-sdk-image"
