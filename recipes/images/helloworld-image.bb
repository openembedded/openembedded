# Hello world image
# Contains *only* a statically linked hello world init program

IMAGE_INSTALL = "helloworld"
IMAGE_LINGUAS = ""

inherit image
