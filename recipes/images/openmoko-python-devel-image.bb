require openmoko-image.bb

IMAGE_INSTALL += "\
  task-openmoko-python-devel \
  task-python-efl-examples \
  edje-viewer \
"
