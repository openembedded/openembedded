require angstrom-gnome-image.bb

IMAGE_INSTALL += "task-gnome-apps"
IMAGE_BASENAME_append = "-big"
