require initramfs-kexecboot-image.bb

IMAGE_INSTALL = "kexecboot-klibc"
