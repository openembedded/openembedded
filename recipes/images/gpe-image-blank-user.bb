require gpe-image.bb

ROOTFS_POSTPROCESS_COMMAND += "adduser -D user"
