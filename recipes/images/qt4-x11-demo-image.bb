require qt4-x11-base-image.bb

IMAGE_INSTALL += "\
        qt4-demos qt4-examples qt-demo-init \
        qt4-assistant \
        qwt-examples \
"
