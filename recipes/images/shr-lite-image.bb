require shr-image.inc

IMAGE_BASENAME = "lite"
