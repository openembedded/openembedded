IMAGE_LINGUAS = ""
IMAGE_INSTALL = "task-pivotboot"

DEPENDS = "task-pivotboot"

inherit image
