DEPENDS = "${MACHINE_TASK_PROVIDER} bootchart"

IMAGE_LINGUAS = ""
IMAGE_INSTALL = "${MACHINE_TASK_PROVIDER} bootchart acct"

inherit image

