require qt4e-base-image.bb

IMAGE_INSTALL += "\
        qt4-embedded-demos qt4-embedded-examples qt-demo-init \
	qt4-embedded-assistant \
	qwt-e-examples \
"
