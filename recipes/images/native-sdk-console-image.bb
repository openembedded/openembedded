require console-image.bb 
IMAGE_INSTALL += "task-native-sdk"
