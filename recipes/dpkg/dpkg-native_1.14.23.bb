require dpkg-native.inc

PR = "r1"

SRC_URI[md5sum] = "9c1744d32ceed71cbe1db863f64d329d"
SRC_URI[sha256sum] = "7d27f2389e05b8727c6a7126c0b65d67749c170ba143e648912a88f2fe707bca"