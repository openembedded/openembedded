require dpkg-native.inc

SRC_URI[src.md5sum] = "4326172a959b5b6484b4bc126e9f628d"
SRC_URI[src.sha256sum] = "ea7ec1c861af43ba534a0d7997774a5f1fd4e25a7eea4ff229c9c7bf89aed633"

PR = "r1"
