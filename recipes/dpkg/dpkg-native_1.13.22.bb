require dpkg-native.inc

PR = "r5"
