require dpkg-native.inc

PR = "r1"
