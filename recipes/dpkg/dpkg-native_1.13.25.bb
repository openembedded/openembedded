require dpkg-native.inc

PR = "r1"

SRC_URI[md5sum] = "88effb358aa04d25036b662d588433a6"
SRC_URI[sha256sum] = "a525f321e875a8c16f5b6942bc02ac66b0d284cc6c61704f93e74789ef89d817"
