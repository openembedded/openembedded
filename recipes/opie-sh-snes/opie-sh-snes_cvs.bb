require ${PN}.inc

PV = "${OPIE_GIT_PV}"
PR = "r2"
