# xfce4-appfinder build file

DESCRIPTION="XFCE Application Finder"
DEPENDS="libxfcegui4 libxfce4menu thunar"
SECTION = "x11"
PR = "r1"

inherit xfce46
