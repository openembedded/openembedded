# xfce4-appfinder build file
# Copyright (C) 2004, Advanced Micro Devices, Inc.  All Rights Reserved
# Released under the MIT license (see COPYING.MIT)

DESCRIPTION="XFCE Application Finder"
SECTION = "x11"
inherit xfce
DEPENDS="libxfcegui4"

SRC_URI[md5sum] = "0bdd0b1e96a1e1cf50ce5d582758b992"
SRC_URI[sha256sum] = "bdf232505f240d0933ca3cd7d2a5c07c31477a70570d95111f94a1226bf7e59c"
