# xfce4-appfinder build file

DESCRIPTION="Xfce4 Application Finder"
DEPENDS="libxfcegui4 libxfce4menu thunar"
SECTION = "x11"
PR = "r0"

inherit xfce46

SRC_URI[md5sum] = "7752e43578b821e35010bcd3762da166"
SRC_URI[sha256sum] = "a1bf35b838922a7f81f588c727a6ef2f56b1bed0c46f7c36b209ac336f7e492a"
