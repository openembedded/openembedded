DESCRIPTION = "Calendar application for the Xfce Desktop  Environment"
DEPENDS = "libxfcegui4 libxfce4util xfce-mcs-manager dbus"

inherit xfce
