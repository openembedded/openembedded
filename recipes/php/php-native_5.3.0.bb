require php-native.inc

PR = "r3"

SRC_URI[src.md5sum] = "846760cd655c98dfd86d6d97c3d964b0"
SRC_URI[src.sha256sum] = "83c9d86f830f8b188c70d3554d07b7416af90fd9e06d84340ffda58c09e58357"
