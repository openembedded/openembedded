require php-native.inc

PR = "r3"
