require jansson.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "c3b88efcf1973d60b19302eae4dfae34"
SRC_URI[sha256sum] = "c74ff4d2b8180f00260284fd3e7876e2aa385f7f3ab410c354a1f937ff902950"
