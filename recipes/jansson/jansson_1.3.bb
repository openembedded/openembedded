require jansson.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "329fc6dbfc20f09b64a1c7392a8afb7f"
SRC_URI[sha256sum] = "06a8874358a596ebc79e8122034350b918b5dc3c13374db182b716aa0d13ba44"
