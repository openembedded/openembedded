require live555.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "8e5ebefdf7d12ca9cfd7175ff3d7eef2"
SRC_URI[sha256sum] = "695cf22d43516f082e26ee9eb8373a0ae3b4ed472f1e224b51d881219f694f2e"

