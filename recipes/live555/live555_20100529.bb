require live555.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "285266fe9ddf6ed1f7bfd6ecae16f742"
SRC_URI[sha256sum] = "9079b577ac20b85378b39ea00a1bf30e09a77763e704d8c5bdc85451257a8f72"

