require live555.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "978cd8443735d47b53ee624a985a047e"
SRC_URI[sha256sum] = "39f23d4c140f9a0bfd6fa11f38c75ae8c3b4fab1930ca1acb8ad66e70947dbc1"

