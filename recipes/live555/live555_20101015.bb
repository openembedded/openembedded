require live555.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "29734ddc6fddbb1a3a8f51a6de7a21c5"
SRC_URI[sha256sum] = "278d99c0880f324769164d6872fea88f8d82ec5b87bb66c92035f46ee2f10adc"

