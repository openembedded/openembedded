require gpe-what.inc

do_compile_prepend() {
	rm *.d
}
