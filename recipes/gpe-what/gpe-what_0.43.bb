require gpe-what.inc

PR = "r1"

SRC_URI += " file://set-wm-hint.patch;patch=1;pnum=0"

SRC_URI[md5sum] = "f04e358d686a48157248a7a3ba115bf9"
SRC_URI[sha256sum] = "35b4b6a48f09221c220fb397a3db8725c3c1053a950534310db719fc71123736"
