require gpe-what.inc

SRC_URI[md5sum] = "96c6bcd7bf99ef35bf8c0a8153646ded"
SRC_URI[sha256sum] = "a240c8a09292381c8aabc2207d720b2f285f19fb7e6953cb8bf2b63f65858499"
