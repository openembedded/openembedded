DESCRIPTION = "Shows the current time in the Openmoko panel"
PV = "0.1.0+svnr${SRCPV}"

inherit openmoko-panel-plugin

