DESCRIPTION = "Shows the bluetooth status in the Openmoko panel"
DEPENDS = "bluez-libs libnotify"
SRCREV = "4331"
PV = "0.1.0+svnr${SRCPV}"
PR = "r1"

inherit openmoko-panel-plugin

