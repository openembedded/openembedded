DESCRIPTION = "Shows the battery/AC status in the Openmoko panel"
DEPENDS = "apmd libnotify"
PV = "0.1.1+svn${SVNREV}"

inherit openmoko-panel-plugin

