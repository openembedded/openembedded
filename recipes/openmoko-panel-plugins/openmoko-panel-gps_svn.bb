DESCRIPTION = "Shows the GPS status in the Openmoko panel"
DEPENDS = "gpsd"
PV = "0.1.0+svn${SVNREV}"

inherit openmoko-panel-plugin

