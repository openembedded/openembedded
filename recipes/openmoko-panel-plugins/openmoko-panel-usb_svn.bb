DESCRIPTION = "USB applet for the Openmoko panel"
SRCREV = "3360"
PV = "0.1.0+svnr${SRCPV}"

inherit openmoko-panel-plugin

