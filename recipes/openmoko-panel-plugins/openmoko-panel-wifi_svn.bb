DESCRIPTION = "Shows the wifi status in the Openmoko panel"
DEPENDS = "libmokopanelui2"
PV = "0.0.0+svn${SVNREV}"

inherit openmoko-panel-plugin

