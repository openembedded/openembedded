require libpng.inc

PR = "${INC_PR}.0"

SRC_URI[libpng.md5sum] = "e8b43dc78ef95b3949af7f961d76874b"
SRC_URI[libpng.sha256sum] = "a5e796e1802b2e221498bda09ff9850bc7ec9068b6788948cc2c42af213914d8"
