require libpng.inc

PR = "${INC_PR}.0"

SRC_URI[libpng.md5sum] = "7612af5660cd4b5e8c433ce53bea01a7"
SRC_URI[libpng.sha256sum] = "f6db51aff81b6920203678b29e8c68a5e3703cf5b39ae5e9e56370d17f31b1c4"
