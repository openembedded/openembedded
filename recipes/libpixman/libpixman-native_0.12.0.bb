require libpixman_0.10.0.bb

inherit native

PROVIDES = "libpixman-native"

