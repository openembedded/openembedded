require giblib.inc

PR = "r3"

SRC_URI += "file://pkgconfig.patch;patch=1"

SRC_URI[md5sum] = "06ae3113fdfe9f05a642bd844cc85eab"
SRC_URI[sha256sum] = "42eb6bff68e88ef12a7ac2aa69848aeb29a8b69176b3bd3d9d67cf9a1233fe85"
