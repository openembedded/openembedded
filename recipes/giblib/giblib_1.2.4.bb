require giblib.inc

PR = "r1"

SRC_URI[md5sum] = "c810ef5389baf24882a1caca2954385e"
SRC_URI[sha256sum] = "176611c4d88d742ea4013991ad54c2f9d2feefbc97a28434c0f48922ebaa8bac"
