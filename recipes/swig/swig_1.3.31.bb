require swig.inc

PR = "${INC_PR}.0"

