require swig.inc

PR = "${INC_PR}.0"

DEFAULT_PREFERENCE = "-1"
