require intltool.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "32c196ae14a90c262310890b498d3512"
SRC_URI[sha256sum] = "2bf2e0a4055148cda35eae442a98f7c6c80b0403467cde4248ca6c485b271e1d"
