require intltool.inc

PR = "${INC_PR}.0"
