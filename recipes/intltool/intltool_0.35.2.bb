require intltool.inc

RDEPENDS = "perl-module-text-wrap perl-module-re"
RRECOMMENDS = "perl-modules"

PR = "${INC_PR}.0"
