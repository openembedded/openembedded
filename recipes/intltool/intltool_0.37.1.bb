require intltool.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "860d392f04299c2740d0752501639c3b"
SRC_URI[sha256sum] = "76cceaaaf188dfac032b21eb5dc4c7d231efe7ff180dee85dbf5e18bc5d27fe7"
