require intltool.inc

#RDEPENDS = "libxml-parser-perl"
RRECOMMENDS = "perl-modules"

PR = "${INC_PR}.0"
