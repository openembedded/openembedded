require intltool_${PV}.bb

inherit native
