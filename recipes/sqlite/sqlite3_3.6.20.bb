require sqlite3.inc


SRC_URI[md5sum] = "0faf8fc8ccff5297513c6532b2b4ce23"
SRC_URI[sha256sum] = "c172ce97dc7201f38acdff22df467e1514e7225b88c636145e72a66a4ca6d07d"
