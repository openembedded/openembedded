require sqlite3-native.inc

SRC_URI[md5sum] = "46f92e42243bc51aaa3871645ce78bd5"
SRC_URI[sha256sum] = "cb07a9801a128e2f42cf49b7e9d577b092ab54aa05242655af93491a73a91a1f"
