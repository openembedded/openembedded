require sqlite3.inc

PR = "r0"

SRC_URI[md5sum] = "ed3151ecaeb3f0a484195da5f694c773"
SRC_URI[sha256sum] = "99bcda2aaf7109a2859ee88aec1f370f61e461343c9bce6cc37f1bed5d933f67"
