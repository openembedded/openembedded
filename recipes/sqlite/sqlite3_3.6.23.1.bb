require sqlite3.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "d99f1b31da0eb33271464bee15cec701"
SRC_URI[sha256sum] = "1a0517438a573a68ab73e8ed75d194086d55d75883542ab1d5ae1080bbddd492"
