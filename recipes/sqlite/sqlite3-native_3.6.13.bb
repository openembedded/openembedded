require sqlite3-native.inc

SRC_URI[md5sum] = "652a01797e7538811e4997a5847bc026"
SRC_URI[sha256sum] = "2ca2591847df72224dd6f99c8fffe35bb63bf41a8519d8e15ad48141aa841bfa"
