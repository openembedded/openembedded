require sqlite3.inc

PR="r1"
DEPENDS += "tcl-native" 
