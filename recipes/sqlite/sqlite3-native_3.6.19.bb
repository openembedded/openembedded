require sqlite3-native.inc

PR="r1"
DEPENDS += "tcl-native"
