include modphp5.inc
PR ='r3'

SRC_URI[md5sum] = "08e423aa314369d4392a36b3f7246afc"
SRC_URI[sha256sum] = "3e9510ce715f28b7e6b803fcdadb73b37c83792c0b5e1e9bcb066ab972649996"
