require which.inc

LICENSE = "GPLv3+"
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "95be0501a466e515422cde4af46b2744"
SRC_URI[sha256sum] = "d417b65c650d88ad26a208293c1c6e3eb60d4b6d847f01ff8f66aca63e2857f8"
