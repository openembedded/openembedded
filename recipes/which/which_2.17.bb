require which.inc

LICENSE = "GPLv2+"
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "c9d33b7c8ce5acc69105e13d56ef0dad"
SRC_URI[sha256sum] = "176fe9c451487eda787dd58d9469d48c95509f49dbb34a574004a936905dd6da"
