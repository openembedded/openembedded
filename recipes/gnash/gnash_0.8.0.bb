require gnash.inc

PR = "r2"

SRC_URI[md5sum] = "b3a3b22d608b5050b1b2743bc348c536"
SRC_URI[sha256sum] = "ff8c3ca6f297ad4fa7cc8fecea45119dbaf8fef7f95901c04eccbf0d6424ef84"
