require gnash-minimal.inc

PR = "r4"

SRC_URI[md5sum] = "05cac831181be3fb40cbf3c00ab25c0f"
SRC_URI[sha256sum] = "4c81e71e6619b79da9641a90ed2c73c362603103bcdcc7b9cc5cc53739d06baa"
