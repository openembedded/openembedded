require gnash.inc

PR = "r2"

SRC_URI[md5sum] = "5f80a25cb7a37fb351d28fd2097d8f3e"
SRC_URI[sha256sum] = "30fb283e707bc209109ca313c83b069b1c482497b62f8c4cc37e9a23e0ba8993"
