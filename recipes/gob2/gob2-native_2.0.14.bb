require gob2_${PV}.bb
DEPENDS = "bison-native flex-native"
inherit native


