include libnfnetlink.inc

PR = "${INC_PR}.0"
SRC_URI[libnfnetlink-0.0.39.md5sum] = "348fed8c1edbe5b873ffc7b192140093"
SRC_URI[libnfnetlink-0.0.39.sha256sum] = "9cd2317dac67fd2161565a21c7b3f9f43b6b6cd93441233226310478ffd4bf50"
