require sysstat.inc
PR = "${INC_PR}.0"


SRC_URI[md5sum] = "84eb313f4bac5b3fe1ed37f1eaf79d04"
SRC_URI[sha256sum] = "26c05ef7666881eb1d60291a4293e67d75dbf048ca8a30f6b9eb3dc86ad1b6b0"
