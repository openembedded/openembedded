require sysstat.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "c05ca01878a4069199d9af93cbe39c8e"
SRC_URI[sha256sum] = "464a4e23ab3b7d6886a5b8aa108e05b1a7f42654e1c398a040c88c81f30168c9"
