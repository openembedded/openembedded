require klibc.inc
require klibc-${PV}.inc
PR = "${INC_PR}.0"
