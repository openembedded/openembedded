require klibc_1.5.15.inc
PR = "r1"

KLIBC_FETCHDIR = "Testing"
