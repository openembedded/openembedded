require klibc-utils-static.inc
require klibc_${PV}.inc
PR = "${INC_PR}.0"
