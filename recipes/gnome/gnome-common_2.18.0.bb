require gnome-common.inc

SRC_URI[archive.md5sum] = "567172e685fc0783b1d6ab9843a85d6a"
SRC_URI[archive.sha256sum] = "ba28c1017e7e4212db16ada3f44cb446b6637c9c4fe16c0e2c2a51c94c46bc5b"
