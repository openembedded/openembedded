require libbonobo.inc

PR = "r2"

SRC_URI[archive.md5sum] = "d99ababb4569c66c3002cba97b076c31"
SRC_URI[archive.sha256sum] = "631f5a27399497fd8bc58be5337ea2cde153c9e6b8e5aa5077704fd887844fd0"
