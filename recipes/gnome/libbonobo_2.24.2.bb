require libbonobo.inc


SRC_URI[archive.md5sum] = "5c7c5ea9c2f78a3c1e9ff2f1e27ad751"
SRC_URI[archive.sha256sum] = "95c0230a31a657e1873fc601318bbaa16722986699219317053f1cd1aa2a28bf"
