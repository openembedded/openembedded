DESCRIPTION = "Gnome keyring library"
LICENSE = "GPL"
SECTION = "x11/gnome"
DEPENDS = ""

inherit gnome lib_package

SRC_URI[archive.md5sum] = "c42b2ca66204835d901d3dbfc1fa5ae6"
SRC_URI[archive.sha256sum] = "56388c0d81ddfdb57d30e4963c83ecc1c18498aab99395420e0fff69929a0f0c"

