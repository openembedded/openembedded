require gnome-common.inc

PR = "r1"

SRC_URI[archive.md5sum] = "30daabb0ca4898fea2647999e7813e8f"
SRC_URI[archive.sha256sum] = "dd4817103d23745d00c735dd137951552ba7b576cb8f68e6a529d06661e9b6a1"
