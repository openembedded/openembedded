require gnome-doc-utils.inc

PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "5934c08d12407d8233416343cd73df24"
SRC_URI[archive.sha256sum] = "6bb8ec068558e380aff1e3f0aa130b52161ad68f8d495fce45c55783bbba9076"
