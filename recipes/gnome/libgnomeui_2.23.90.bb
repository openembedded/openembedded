require libgnomeui.inc


SRC_URI[archive.md5sum] = "310ede3d7fd6dbdb0f53bfa7af46f09a"
SRC_URI[archive.sha256sum] = "1f112ea46c51e063f4085e27b97c88d4e23164eb07056edbbee1a190abe713ec"
