DESCRIPTION = "Gnome network tool"
LICENSE = "GPL"
SECTION = "x11/gnome"
DEPENDS = "gtk+ gconf libgtop"

inherit gnome

SRC_URI[archive.md5sum] = "2087259219cf16d434c52b4a5710b4c7"
SRC_URI[archive.sha256sum] = "42fdc867d26b31145986fd99e06509229b118430f2d666070c5dac7cff1dd000"

