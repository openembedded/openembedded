require gnome-common.inc

SRC_URI[archive.md5sum] = "89e47677fb72695c75d2cefac84ff9f1"
SRC_URI[archive.sha256sum] = "0e807cfe74a684c494a0949b7f96d231660f323253a89053e3ec32c4f518c8d9"
