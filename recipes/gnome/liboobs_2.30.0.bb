LICENSE = "LGPL"
DEPENDS = "glib-2.0 dbus system-tools-backends"

inherit gnome lib_package

SRC_URI[archive.md5sum] = "69ee6d329cd919c69aae3dae7302b796"
SRC_URI[archive.sha256sum] = "b0c18e038a6c1eba15c68a8e9fabfc21144c9240c17f3bd19042bae1ea04a5ce"


