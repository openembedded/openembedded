DESCRIPTION = "Editor for the gnome registry"
LICENSE = "GPLv2"
DEPENDS = "gnome-doc-utils gconf"

inherit gnome gconf


