require libgnomeui.inc


SRC_URI[archive.md5sum] = "7d50e1fc4c1ee3c268b26e8dfe7e677b"
SRC_URI[archive.sha256sum] = "9ecf81d3ad2e1ec0b371d720b37154e8b716af1cd464dbeb06232f8fa4c5e07d"
