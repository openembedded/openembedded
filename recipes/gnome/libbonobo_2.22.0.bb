require libbonobo.inc

PR = "r0"

SRC_URI += "file://configure-gthread.patch;patch=1"


SRC_URI[archive.md5sum] = "998a576ad26784ac87eab99e96013527"
SRC_URI[archive.sha256sum] = "5a6d96b9b15afa5d1702eee3a1ee3e50c3cfedb65d7c3faad64036ccfb3294b4"
