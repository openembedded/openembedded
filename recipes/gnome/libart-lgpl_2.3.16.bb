require libart-lgpl.inc

PR = "${INC_PR}.1"


SRC_URI[md5sum] = "6bb13292b00649d01400a5b29a6c87cb"
SRC_URI[sha256sum] = "18dc03fcf7514b0b0b0597e39c79353e00dd9d057aedaa5e14d4f08b8f92065f"
