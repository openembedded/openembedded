DESCRIPTION = "C++ bindings for GConf"
LICENSE = "LGPLv2"
DEPENDS = "glibmm gconf gtkmm"

inherit gnome

SRC_URI[archive.md5sum] = "dad2999d8bbf88cf581fa512041d735e"
SRC_URI[archive.sha256sum] = "3daa3719f773cfc9fcee84766f60eab4579209978425221997120662bd621a52"
