require libbonobo.inc

PR = "r2"

SRC_URI[archive.md5sum] = "68179b91f5043ce0ef050dbbed04979b"
SRC_URI[archive.sha256sum] = "b1a185c6e20ac50c95ec3ba1aca486819984cd213e9cea69ab0dbca21db78b92"
