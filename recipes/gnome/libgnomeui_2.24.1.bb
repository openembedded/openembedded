require libgnomeui.inc

