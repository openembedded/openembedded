require gnome-desktop.inc

PR = "r1"

inherit gnome pkgconfig

SRC_URI[archive.md5sum] = "b912a6878ea307af9e3d015864ec0678"
SRC_URI[archive.sha256sum] = "de8ba10bf7321b70ba5b3bdd45b61411b5a9fbd401fbe639041a875be01bd8f4"
