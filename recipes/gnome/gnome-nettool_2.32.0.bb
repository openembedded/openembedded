DESCRIPTION = "Gnome network tool"
LICENSE = "GPL"
SECTION = "x11/gnome"
DEPENDS = "gtk+ gconf libgtop"

inherit gnome

SRC_URI[archive.md5sum] = "af5436deb30ccfb3f6a1f8ea5602c40d"
SRC_URI[archive.sha256sum] = "8c70f85952760170114b2fa4be3ccaa3fc6298f802bacda2503ed482b8a0539c"

