inherit gnome

SRC_URI[archive.md5sum] = "c7436ebabf72d2351d05f4dcba4ff0a7"
SRC_URI[archive.sha256sum] = "9a2edcbdd43fb79c194f5eda45efe5362ef395e7f637aae33bceea8f9c24890d"

