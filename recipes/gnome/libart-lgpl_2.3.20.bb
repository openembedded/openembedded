require libart-lgpl.inc

PR = "${INC_PR}.1"

