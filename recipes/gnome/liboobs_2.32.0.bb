LICENSE = "LGPL"
DEPENDS = "glib-2.0 dbus system-tools-backends"

inherit gnome lib_package

SRC_URI[archive.md5sum] = "0bb40041b7227f9060ab51f3022115df"
SRC_URI[archive.sha256sum] = "1b70061272b2c777d505b5b6c785e045d4297639dd0d4214d04dea154a9b63d6"


