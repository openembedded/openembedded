require libbonobo.inc

PR = "r1"

SRC_URI[archive.md5sum] = "078942cb9c6a1a31f93958e993353f45"
SRC_URI[archive.sha256sum] = "cd579e8dff38882d685be01449db92dad7c78900885d5a9abf6160756f83a7a8"
