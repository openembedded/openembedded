LICENSE = "LGPL"
DEPENDS = "glib-2.0"

inherit gnome lib_package

SRC_URI[archive.md5sum] = "994c299b6dba330524a67ea45776b3ab"
SRC_URI[archive.sha256sum] = "0a7e0e7d736a608a5ed25f8e475a87bf38e61dbef66822e25e8ef50705cf70f6"


