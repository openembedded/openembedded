require gnome-doc-utils.inc

PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "21fe881ab473fdc9246c36bd8ef929b0"
SRC_URI[archive.sha256sum] = "5b51e0dfae64e7f48883fce6657fcf47a03f6429e2c67024203e31cc29032a22"
