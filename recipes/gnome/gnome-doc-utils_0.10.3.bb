require gnome-doc-utils.inc

PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "43f3a4086ec1254cbe20b85948192d18"
SRC_URI[archive.sha256sum] = "19b5b4425bc578af8a1c58b61f1b9a416743d0b1fae3356cd9a0071f1f66632c"
