require libgnomeui.inc


SRC_URI[archive.md5sum] = "dbdb274517ad643d9397dd6868788631"
SRC_URI[archive.sha256sum] = "d6eef491e70fcc2c1e5b94f6a8dbb3774443b3b76b1ca5d62bfb5b802df14120"
