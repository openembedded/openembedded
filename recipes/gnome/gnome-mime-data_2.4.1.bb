LICENSE = "GPL"
inherit gnome

DEPENDS += "intltool-native"
PR = "r1"

SRC_URI[archive.md5sum] = "a8bd52c6876a5294abc402f8a581ac1a"
SRC_URI[archive.sha256sum] = "74846344de2c24a76408ee9c598dbc75d6c33a02f888f8b5491cb1af9a097cb4"
