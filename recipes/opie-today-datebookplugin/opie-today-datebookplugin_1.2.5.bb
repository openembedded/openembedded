require ${PN}.inc

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_core_pim_today_plugins_datebook.tar.bz2;name=split_core_pim_today_plugins_datebook"
SRC_URI[split_core_pim_today_plugins_datebook.md5sum] = "45c0402091d58cb7c0d793ec5c6da4ba"
SRC_URI[split_core_pim_today_plugins_datebook.sha256sum] = "d834f034a472f1e69d25cecc4065e0c2f5b0011472169539ac859b6caeea54b6"
