require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_core_pim_today_plugins_datebook.tar.bz2;name=split_core_pim_today_plugins_datebook"
SRC_URI[split_core_pim_today_plugins_datebook.md5sum] = "65d7a6d6c25a2d8dd6b1f99105a2f561"
SRC_URI[split_core_pim_today_plugins_datebook.sha256sum] = "a44d36525cee0a1adde02a14ed5c25bec4d46d85ef9819e0650fb1a15e20a77f"
