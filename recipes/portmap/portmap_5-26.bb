require portmap.inc

SRC_URI[md5sum] = "781e16ed4487c4caa082c6fef09ead4f"
SRC_URI[sha256sum] = "e8fb4429ecf03809f60b2e194be120a811be1c5cc3cc5d933ede938114357b61"
SRC_URI[md5sum] = "11118c91a095e8ff7f4a3f5f09062be7"
SRC_URI[sha256sum] = "8478eee317686f53e24519657f4653293bd120fae9815153d7cf54e0f8be9feb"
