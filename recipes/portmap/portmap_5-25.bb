require portmap.inc

SRC_URI[archive.md5sum] = "781e16ed4487c4caa082c6fef09ead4f"
SRC_URI[archive.sha256sum] = "e8fb4429ecf03809f60b2e194be120a811be1c5cc3cc5d933ede938114357b61"
SRC_URI[patch.md5sum] = "b78c2ecfe378b03b8f1b36d2aed94eac"
SRC_URI[patch.sha256sum] = "09595393c56b24d45476bf414f9e32cf13d675711c8ac3f7e0754c938814e085"
