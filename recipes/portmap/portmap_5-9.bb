require portmap.inc

PR = "r5"

SRC_URI[archive.md5sum] = "781e16ed4487c4caa082c6fef09ead4f"
SRC_URI[archive.sha256sum] = "e8fb4429ecf03809f60b2e194be120a811be1c5cc3cc5d933ede938114357b61"
SRC_URI[patch.md5sum] = "8b77092f74e5638e90825973f0274729"
SRC_URI[patch.sha256sum] = "a9ab1930048038d80a9e48e69a6f0d57e86a355545d6db3e2c67e06ec909b80a"
