# xfprint OE build file
# Copyright (C) 2004, Advanced Micro Devices, Inc.  All Rights Reserved
# Released under the MIT license (see packages/COPYING)

DESCRIPTION="XFCE4 Print Manager"
SECTION = "x11/base"

DEPENDS="libxfcegui4"
inherit xfce

SRC_URI[md5sum] = "c2eb9dee0002e875b91e73557f7354a1"
SRC_URI[sha256sum] = "4eee12555dbc296fa26afbfdbfabad3586000239d5666e54b6bfae7f8cd03e89"
