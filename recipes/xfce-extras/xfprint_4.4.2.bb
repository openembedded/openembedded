# xfprint OE build file
# Copyright (C) 2004, Advanced Micro Devices, Inc.  All Rights Reserved
# Released under the MIT license (see COPYING.MIT)

DESCRIPTION="XFCE4 Print Manager"
SECTION = "x11/base"

DEPENDS="libxfcegui4"
inherit xfce

SRC_URI[md5sum] = "be4802807e74dea30f4825102ceff5c5"
SRC_URI[sha256sum] = "b9bb03820a8ba1995ffe3e5b96b6d5ebbbc0347ad1202172f13bba63b2984d54"
