# xfce-calendar OE build file
# Copyright (C) 2004, Advanced Micro Devices, Inc.  All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require ${PN}.inc

SRC_URI = "http://www.us.xfce.org/archive/xfce/${XFCE_VERSION}/src/${PN}-${PV}.tar.gz"

SRC_URI[md5sum] = "d964e45cc1d21f482f5e303129491987"
SRC_URI[sha256sum] = "910a65a81b7efb18e638105a46cb1249df041df6e66fcfcb58ac7e95baaa7976"