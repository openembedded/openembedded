DESCRIPTION = "Text editor for Xfce based on Leafpad"
DEPENDS = "libxfce4util xfce-mcs-manager hal liburi-perl-native python-native"

inherit xfce
XFCE_VERSION = 4.4.2
