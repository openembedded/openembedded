DESCRIPTION = "Calendar application for the Xfce Desktop  Environment"
DEPENDS = "libxfcegui4 exo libxml-parser-perl-native xfce4-panel xfce-mcs-manager"
RREPLACES = "xfcalendar"

inherit xfce

SRC_URI[md5sum] = "0c69e4c20350c3000d49350991d3a520"
SRC_URI[sha256sum] = "ef08b96e5529f19a2f609525300fbea2019f1afb75fb3c85e474e6041f425abd"
