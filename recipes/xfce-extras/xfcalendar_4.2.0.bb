# xfce-calendar OE build file
# Copyright (C) 2004, Advanced Micro Devices, Inc.  All Rights Reserved
# Released under the MIT license (see packages/COPYING)

DESCRIPTION="XFCE Calendar"
SECTION = "x11"
DEPENDS = "virtual/libx11 libxfcegui4 libxfce4mcs"
inherit xfce

SRC_URI[md5sum] = "5b94497a0e2f5c78b1689adc8aa8a85f"
SRC_URI[sha256sum] = "4e7d4e9f235a4238d20364a5ffa0b1d73f24b6c8d4e79c1fcb09b13a4eb53e50"
