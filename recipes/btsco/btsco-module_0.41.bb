require btsco-module.inc

PR = "r1"

SRC_URI[md5sum] = "5a7760ed42d7a8b02cbfc77c4e97647c"
SRC_URI[sha256sum] = "0b71cda89cee84cba28cac91e90a30b9648ce09a16e761a370fb171a7ca12657"
