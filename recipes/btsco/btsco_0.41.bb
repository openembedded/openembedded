require btsco.inc

PR = "r2"

SRC_URI[md5sum] = "111efb0f7092c92c4dd376eec96aa2e7"
SRC_URI[sha256sum] = "47d206a511347f0762f4fe02c71d5b3a6122dcf3947947723cdde1d91ebad01b"

