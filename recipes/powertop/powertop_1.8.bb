require powertop.inc
PR = "${INC_PR}.0"


SRC_URI[md5sum] = "38fd8a6825cd62b6c22df8a44b4e27d0"
SRC_URI[sha256sum] = "7325ea46e5af59c12ea024e69622ac7753010c8de615d668e1f03b0fc05bad3a"
