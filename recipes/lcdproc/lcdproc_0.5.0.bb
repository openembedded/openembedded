require lcdproc5.inc