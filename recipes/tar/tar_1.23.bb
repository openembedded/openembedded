require tar.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "41e2ca4b924ec7860e51b43ad06cdb7e"
SRC_URI[sha256sum] = "c9328372db62fbb1d94c9e4e3cefc961111af46de47085b635359c00a0eebe36"
