require tar.inc

SRC_URI[md5sum] = "1a7e17f27abf583b3b0bc059a827e68b"
SRC_URI[sha256sum] = "be8bf33afb5adc2377e45d94693ffd46b75f267f9b808df0c7006e51211f9deb"
