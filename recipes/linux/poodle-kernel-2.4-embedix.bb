MACHINE = "poodle"
COMPATIBLE_HOST = "arm.*-linux"

require openzaurus-pxa_2.4.18-rmk7-pxa3-embedix20031107.inc
