require linux_${PV}.bb
require linux-openmoko.inc
OM-PR = "1"
