require linux-omap3.inc

COMPATIBLE_MACHINE = "ti816x"

KVER = "2.6.34"
PSPREL = "04.00.00.06"

BRANCH = "ti816x-master"
# Use literal tags in SRCREV, when available, instead of commit IDs
SRCREV = "de5ce6556f41711317a44878fc68839e4d899268"
