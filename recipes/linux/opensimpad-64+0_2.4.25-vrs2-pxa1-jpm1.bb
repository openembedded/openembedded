SECTION = "kernel"
require opensimpad_${PV}.bb

SIMPAD_MEM = "64"
SIMPAD_RD = "0"
