require linux_${PV}.bb
require linux-openmoko.inc
