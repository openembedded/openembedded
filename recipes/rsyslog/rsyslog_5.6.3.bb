require rsyslog.inc
PR = "${INC_PR}.0"

SRC_URI[md5sum] = "4fd22c5a4d9442b16f6717c65446b718"
SRC_URI[sha256sum] = "d78547097add18a7bc680899a87f3305926b3a57b4885fc8fc31e7014c29dc7b"
