require confuse_${PV}.bb

inherit native
