require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_core_applets_aboutapplet.tar.bz2;name=split_core_applets_aboutapplet"
SRC_URI[split_core_applets_aboutapplet.md5sum] = "1373b4db8614d84f90494bf875389f01"
SRC_URI[split_core_applets_aboutapplet.sha256sum] = "bdf593574753c040bf9c2ba5bf0f0c8d5cc30d129003cc16492e15e4352244ab"
