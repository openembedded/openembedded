require didiwiki.inc

SRC_URI[md5sum] = "94d5fb06d091804b31658481f23b120f"
SRC_URI[sha256sum] = "31e8e536f5efd7d7d1d5f4e4458b42aa9cd7910acf3da933cb7fa3507cf7f752"
