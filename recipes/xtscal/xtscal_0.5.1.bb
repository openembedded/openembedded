require xtscal.inc

PR = "r1"

SRC_URI += "file://xtscal-poodle.patch;patch=1"

SRC_URI[md5sum] = "9ae79f1c64551a1cacf506fde6d83ef6"
SRC_URI[sha256sum] = "39c354adb9783fc30d4df6edbe04f68b69d5005b1bd7353dca506ced3b8b594e"
