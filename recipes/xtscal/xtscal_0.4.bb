require xtscal.inc
