require cornucopia.inc
DESCRIPTION = "freesmartphone.org support library"
DEPENDS += "libfsobasics alsa-lib"
PV = "0.8.0+gitr${SRCPV}"
PE = "1"
PR = "${INC_PR}.0"

