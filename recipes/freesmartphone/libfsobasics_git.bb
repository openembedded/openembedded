require cornucopia.inc

DESCRIPTION = "freesmartphone.org support library"
DEPENDS += "libnl2"
PV = "0.8.2.0+gitr${SRCPV}"
PE = "1"
PR = "${INC_PR}.0"
