require cornucopia.inc
DESCRIPTION = "freesmartphone.org dbus resource library"
DEPENDS += "libfso-glib"
PV = "0.1.1+gitr${SRCPV}"
PE = "1"
PR = "${INC_PR}.0"
