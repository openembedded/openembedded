require cornucopia.inc
inherit fso-plugin
PV = "0.1.0+gitr${SRCPV}"
PE = "1"
PR = "${INC_PR}.0"
