require ${PN}.inc
PR = "r1"


SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_core_multimedia_opieplayer.tar.bz2;name=split_core_multimedia_opieplayer"
SRC_URI[split_core_multimedia_opieplayer.md5sum] = "64271b17f8dd9f968e82d4f66d810c53"
SRC_URI[split_core_multimedia_opieplayer.sha256sum] = "47b43dd5883780d04f825dda7dfa1a53355deb548e59a49c01a330e9d88360aa"
