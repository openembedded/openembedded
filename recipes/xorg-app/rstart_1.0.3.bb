require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11"


SRC_URI[archive.md5sum] = "e09c14cf1ac78260f95a9aa45bccab4c"
SRC_URI[archive.sha256sum] = "d6ee7becf9ece2fcc30ce50f7e9be31f231cce0cb3a8ba09d1697ac2822c3fcc"
