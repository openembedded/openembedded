require xorg-app-common.inc
DEPENDS += " libxmu "
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "ee97f0cbb80e321c914dc7bc5d49960a"
SRC_URI[archive.sha256sum] = "2a2c79826109a8c8a6affec8ff1f3ddada53d20d33c8ea1dd8788385fceb9952"
