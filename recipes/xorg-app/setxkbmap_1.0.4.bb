require xorg-app-common.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " libxkbfile virtual/libx11"


SRC_URI[archive.md5sum] = "6fab3bb176be9e510c5613d054ef1ca4"
SRC_URI[archive.sha256sum] = "9b5b139238419757d57de584c2ad30b853367245eef49221ce02a3b403cf2bac"
