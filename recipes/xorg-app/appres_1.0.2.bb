require xorg-app-common.inc
PE = "1"

DESCRIPTION = "The appres program prints the resources seen by an application."

DEPENDS += " virtual/libx11 libxt"


SRC_URI[archive.md5sum] = "6f2f5d9f41669d498b56d73dc3206951"
SRC_URI[archive.sha256sum] = "37d0fbb16c553fa09878d107f29f26c2ca4206c98dd23c44a0cb670ace531e36"
