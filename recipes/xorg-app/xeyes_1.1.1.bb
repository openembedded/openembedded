require xorg-app-common.inc
DEPENDS += " libxau libxt libxext libxmu"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "a3035dcecdbdb89e864177c080924981"
SRC_URI[archive.sha256sum] = "975e98680cd59e1f9439016386609546ed08c284d0f05a95276f96aca6e8a521"
