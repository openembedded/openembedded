require xorg-app-common.inc
DEPENDS += " xcb-util"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "760099f0af112401735801e3b9aa8595"
SRC_URI[archive.sha256sum] = "1ce5f3987b63ea79b3f8421fcb1dd9c739e99efa97f280eafd8e93574b9027d1"
