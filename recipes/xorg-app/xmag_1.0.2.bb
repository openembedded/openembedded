require xorg-app-common.inc

DESCRIPTION = "magnify parts of the screen"
DEPENDS += " libxaw libxt"
PE = "1"

SRC_URI[archive.md5sum] = "7c6a783e42c88360ac31d259a864a19d"
SRC_URI[archive.sha256sum] = "51dd943e607ddd8067fd13cd597998fb00560cbf06450a8c374563a78a86da43"
