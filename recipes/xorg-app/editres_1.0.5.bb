require xorg-app-common.inc
DEPENDS += " libxt libxmu libxaw"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "87e499fd2599910af7961187205ca7ed"
SRC_URI[archive.sha256sum] = "fd97a3522e97b8b7ead7b5cddeb79bfabe44769d144ac9ae5595c25c41afa33d"
