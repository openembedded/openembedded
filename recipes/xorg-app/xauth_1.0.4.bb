require xorg-app-common.inc

DESCRIPTION = "X authority file utility"
DEPENDS += "libxau libxext libxmu"
PE = "1"

SRC_URI[archive.md5sum] = "fa00078c414c4a57cab7a6d89a0c8734"
SRC_URI[archive.sha256sum] = "f91190c8b8bb18270b86b00f30da5684bb5e5bd1ed0ccf352322f8145e076a59"
