require xorg-app-common.inc
DEPENDS += " libxmu libxext "
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "908f8bc3255f639effa9780fb1c19ea4"
SRC_URI[archive.sha256sum] = "8db6b81a7b0bc4e7acce6c6d41df9747b0b19e12c21c5a70b51bbc63a42cdcd9"
