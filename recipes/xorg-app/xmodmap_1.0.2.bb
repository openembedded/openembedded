require xorg-app-common.inc

DESCRIPTION = "utility for modifying keymaps and pointer button mappings in X"
LICENSE = "MIT"
PE = "1"

SRC_URI[archive.md5sum] = "ea78b3e32e27c3662f86ea68b3aec22f"
SRC_URI[archive.sha256sum] = "4bed79ba6efcaabb3ce055cf88419a5190f8ab9d3408e7b14d722351cbaf4b44"
