require xorg-app-common.inc
DEPENDS += " libice xproxymanagementprotocol"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "eeb558aad30a8b2bc1f1f0e919ea6f38"
SRC_URI[archive.sha256sum] = "8b3df86d875d5a00743fe74f181eb4827e26a849073b5acd163677dca53de2e1"
