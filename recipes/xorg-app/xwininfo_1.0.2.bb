require xorg-app-common.inc
PE = "1"

DEPENDS += " libxmu libxext virtual/libx11"


SRC_URI[archive.md5sum] = "e5dbc8866a55958297f5f38205b6be1e"
SRC_URI[archive.sha256sum] = "9fdfd3259b335531cdba831872ec0e32c5f6df01e14b87c3187b494be75b7b66"
