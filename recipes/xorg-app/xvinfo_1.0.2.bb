require xorg-app-common.inc

DESCRIPTION = "Print out X-Video extension adaptor information"
DEPENDS += " libxv"
PE = "1"

SRC_URI[archive.md5sum] = "e1e318436f49e2f0f3764593dadd9ad2"
SRC_URI[archive.sha256sum] = "126e2a612ac723f9688904fcfa612688d62e520ce55c56eb34eb5390074cf150"
