require xorg-app-common.inc
DEPENDS += " libxaw libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "2c6ecedb10dc51adbb64c95f22fd99c2"
SRC_URI[archive.sha256sum] = "3399a27101285112ea578e1855c8374254afa8d427a3c5943458abc27c4d70fc"
