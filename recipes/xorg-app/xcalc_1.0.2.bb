require xorg-app-common.inc
DESCRIPTION = "scientific calculator for X"
DEPENDS += " libxaw libxt"
PE = "1"

SRC_URI[archive.md5sum] = "d31a99795b9668f047aa11bf36df6df0"
SRC_URI[archive.sha256sum] = "96375e2d212e7249d14d0beac73c1a6d89252b5fcf571bd9f5c7303a14bb4a32"
