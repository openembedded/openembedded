require xorg-app-common.inc

DESCRIPTION = "X server resource database utility"
LICENSE = "xrdb"
DEPENDS += "libxmu"
PE = "1"

SRC_URI[archive.md5sum] = "380b2ef545306354cc150834de567be7"
SRC_URI[archive.sha256sum] = "a4a3b8cd821adc201a072f8c0214d73ee6a7e7b898de90e18f7d89a4453fb12c"
