require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11 libxxf86vm"


SRC_URI[archive.md5sum] = "45d8fa3c85d4bfda87251798fd605a45"
SRC_URI[archive.sha256sum] = "085330064fdb90a152d2d44474fa20bb81ccb6c587c144f5f9c323cb9cc31eee"
