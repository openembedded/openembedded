require xorg-app-common.inc
PE = "1"

DESCRIPTION = "X fontserver"

DEPENDS += " libfs libxfont xtrans"


SRC_URI[archive.md5sum] = "f43cb64d623b748208dfd9012d17b654"
SRC_URI[archive.sha256sum] = "452dde2923c7ae5a2b8cb4b9735507c579c1c55a0e5e45a34210e52574ee641b"
