require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11"


SRC_URI[archive.md5sum] = "99aea04a27197056368a4431f30f9cdb"
SRC_URI[archive.sha256sum] = "02fc48b5069018e4262f0e5ebb669acedc04167307c98f0fdb2ca22e568e9596"
