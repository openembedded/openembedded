require xorg-app-common.inc
DESCRIPTION = "print an X window dump"
DEPENDS += " libxmu "
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "1c2c540d240def3ea65ff2030f059f8a"
SRC_URI[archive.sha256sum] = "2878d6b04ef81ec415fa81313565bee521bf94132127615b9d717d5a489b937d"
