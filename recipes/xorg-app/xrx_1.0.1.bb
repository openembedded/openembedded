require xorg-app-common.inc
PE = "1"

DEPENDS += " libxaw virtual/libx11 libxt libxext xtrans xproxymngproto libxau"


SRC_URI[archive.md5sum] = "5f65e24f8a225e255beb2059e33d6b37"
SRC_URI[archive.sha256sum] = "a51ac7c607f2f79de771807f590ccfe8b1819dae6f30dd615dd2afbe6007c4e4"
