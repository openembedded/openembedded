require xorg-app-common.inc
PE = "1"

DEPENDS += " libfs"


SRC_URI[archive.md5sum] = "339b2faf1ca5114fda414338e15b6e21"
SRC_URI[archive.sha256sum] = "87db3cf12914abc6b074d12b35c7f39c8fd7b5d3933b339e2c1260a51061760c"
