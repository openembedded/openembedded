require xorg-app-common.inc

DESCRIPTION = "Sets the visual appearance of the X root window"
LICENSE = "MIT"
DEPENDS += "libxmu xbitmaps"
PE = "1"

SRC_URI[archive.md5sum] = "fc7eeb7130bb54345671a9dbaab567ac"
SRC_URI[archive.sha256sum] = "897d77acd3f4a366472386139827eaac24cc423c811ef0e65e0d5eca099a3155"
