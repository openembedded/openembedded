require xorg-app-common.inc
DESCRIPTION = "scientific calculator for X"
DEPENDS += " libxaw libxt"
PE = "1"

SRC_URI[archive.md5sum] = "0b981e360b54584fcb6dc2ec4658c406"
SRC_URI[archive.sha256sum] = "96c413998c664a8397313d749b20e18308bcd82187a89446a64b3557b089b42f"
