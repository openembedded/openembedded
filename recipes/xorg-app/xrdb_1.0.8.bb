require xorg-app-common.inc
DESCRIPTION = "X server resource database utility"
LICENSE = "xrdb"
DEPENDS += "libxmu"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "55cb47aa28460c34c3f9bac376e7fd78"
SRC_URI[archive.sha256sum] = "ffd847ab7ca510810ca4d5cff223c5c443bbb3ddb0c3665504445267312853e4"
