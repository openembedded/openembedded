require xorg-app-common.inc
DEPENDS += " libxaw libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "07b948cf671fde88df1a59bfb0cab3b8"
SRC_URI[archive.sha256sum] = "17484e5fec0ebe7dd8df7218fde1449c52be3f4c6377a85a9fd86e377a7f4248"
