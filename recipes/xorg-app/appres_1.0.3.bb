require xorg-app-common.inc
DESCRIPTION = "The appres program prints the resources seen by an application."
DEPENDS += " libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "48d56924f76738872ef6c90f99030e34"
SRC_URI[archive.sha256sum] = "93f475046a8c5055131c5551d5a36ff62aa138a7b2f17ac1bf6393cde8dc640a"
