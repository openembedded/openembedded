require xorg-app-common.inc
DEPENDS += " libxp libxprintutil libxp libxau libxext"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "7e730d15679490bd00a8b69e775b3487"
SRC_URI[archive.sha256sum] = "66507b359eb87a7649c9f78aadb7b11efc0a5ffacf9b259392ed54be42cc0d09"
