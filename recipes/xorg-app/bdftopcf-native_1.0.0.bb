inherit native
require xorg-app-common.inc
PE = "1"

XORG_PN = "bdftopcf"

DEPENDS = "libxfont-native"


SRC_URI[archive.md5sum] = "41f4ac6760ef5e671ba8d4baa7236f12"
SRC_URI[archive.sha256sum] = "8c01b85eab01f35ed6bc9d597d4c6c76cf9ddbe2596d9120d66e66135df1f9a1"
