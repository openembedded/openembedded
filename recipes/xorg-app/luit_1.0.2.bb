require xorg-app-common.inc
DEPENDS += " zlib zlib libfontenc"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "aacda46598ce3af8ca16e2a8132db1b2"
SRC_URI[archive.sha256sum] = "c0c4d76df0350c626df7ce62bf3df7915f9959557d76abce96222857d782389c"
