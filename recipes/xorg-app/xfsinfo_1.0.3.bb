require xorg-app-common.inc
DEPENDS += " libfs"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "aae6fa48b5c2ce9186a5ff4ccc14a1d4"
SRC_URI[archive.sha256sum] = "59774492e80525b9bd1adbee5324ae7cd117813063e620b4c2c5d8ada189874f"
