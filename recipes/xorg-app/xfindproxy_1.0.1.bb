require xorg-app-common.inc
PE = "1"

DEPENDS += " libxaw libxt"


SRC_URI[archive.md5sum] = "5df3a162429bdd6ce5aea3ca5f6365b8"
SRC_URI[archive.sha256sum] = "6b585ceadd3e17b433e177d80837e485869d6704f1181b6f3457ae56ba1988ea"
