require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11 libxmu"


SRC_URI[archive.md5sum] = "df270f7dd5528ae1b7d80c47585d8278"
SRC_URI[archive.sha256sum] = "8527cdd29d4fcc67df014bc8b371be98901c9082b8de81ea2302bf705c887698"
