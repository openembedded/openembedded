require xorg-app-common.inc
DESCRIPTION = "monitor system console messages with X"
DEPENDS += " libxt"
PE = "1"

SRC_URI[archive.md5sum] = "0e1a3110bebabecc2897d67a973526b0"
SRC_URI[archive.sha256sum] = "1b1ec25fefad34f5c33c74474358c1f5a8702d8c04defc854826bccb7a46bc45"
