require xorg-app-common.inc
DEPENDS += " libxaw libxprintutil libxp libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "67193be728414d45a1922911e6437991"
SRC_URI[archive.sha256sum] = "a38823a8b7919e2efa689bc4c279e12314e45b41131c39ce9ca523e54f42fa1f"
