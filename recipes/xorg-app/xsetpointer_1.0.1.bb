require xorg-app-common.inc

DESCRIPTION = "set an X Input device as the main pointer"
DEPENDS += " libxi virtual/libx11"
PE = "1"

SRC_URI[archive.md5sum] = "9e5bcbeda4aaf02bfa095e41d30baee4"
SRC_URI[archive.sha256sum] = "495d88871eb5081e98bbae55f813f73cb3ce4145d6ca3e8f2826800166c04571"
