require xorg-app-common.inc
DEPENDS += " libxaw libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "b9102fe787eda2a1c9578079d8f55eed"
SRC_URI[archive.sha256sum] = "26aa23afe14c99317949e1da75d90b8956a73b08ebce972d5b0a99cc01919dbd"
