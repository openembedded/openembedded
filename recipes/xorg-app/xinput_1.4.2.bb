require xorg-app-common.inc

DESCRIPTION = "a utility to configure and test XInput devices"
DEPENDS += " libxi"

SRC_URI[archive.md5sum] = "58e619576cbf4b6057eebb7a97fe2ddf"
SRC_URI[archive.sha256sum] = "3195916b6cebf109eb571b939d7cea7075ef1933782526a6d8fbbb353bc3924b"
