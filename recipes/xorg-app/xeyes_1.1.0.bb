require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11 libxau libxt libxext libxmu"

SRC_URI[archive.md5sum] = "933f6d2b132d14f707f1f3c87b39ebe2"
SRC_URI[archive.sha256sum] = "996b9641fea06e2f0dde9cbf5fb31b5cd139376198057a88ca59820fdb94d507"
