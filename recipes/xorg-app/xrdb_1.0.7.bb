require xorg-app-common.inc
DESCRIPTION = "X server resource database utility"
LICENSE = "xrdb"
DEPENDS += "libxmu"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "93f54f04e0b531b5fb77d3f051cbf22a"
SRC_URI[archive.sha256sum] = "0c70a433f78c1dd3bf02e44e03a7534f3fe3ff45643ecbd7844d0ca3c74157b1"
