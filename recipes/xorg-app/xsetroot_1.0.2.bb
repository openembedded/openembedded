require xorg-app-common.inc

DESCRIPTION = "Sets the visual appearance of the X root window"
LICENSE = "MIT"
DEPENDS += "libxmu xbitmaps"
PE = "1"

SRC_URI[archive.md5sum] = "9af7db9f3052aef0b11636720b3101dd"
SRC_URI[archive.sha256sum] = "4f9a751f4830d479fae8ccb68ed04896dc99612789310b7917bd15c04aa3351d"
