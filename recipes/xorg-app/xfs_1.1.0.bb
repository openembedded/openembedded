require xorg-app-common.inc

DESCRIPTION = "X fontserver"
DEPENDS += " libfs libxfont xtrans"
PE = "1"

SRC_URI[archive.md5sum] = "5cfc06a320f74f07a0aa73da62307e9a"
SRC_URI[archive.sha256sum] = "47bad4bbcd0488a8e573aa6efe3438076c4d27c498d6f642f3aa27262eb95f6d"
