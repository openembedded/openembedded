require xorg-app-common.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " virtual/libx11"


SRC_URI[archive.md5sum] = "bee5d87d40615e67c84ab0b0c65049ba"
SRC_URI[archive.sha256sum] = "c23c12259854c7cec6d19bf397afff4a542a22170b14de73b321aa8cafcf3a86"
