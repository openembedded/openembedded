require xorg-app-common.inc
DEPENDS += " libxaw freetype fontconfig libxft libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "17d8ef0d490301158f8abf7641cca243"
SRC_URI[archive.sha256sum] = "e76db409ac46bd81c80348bea816d72065f36c2ef3d78a0da37ada7ffbeaea1a"
