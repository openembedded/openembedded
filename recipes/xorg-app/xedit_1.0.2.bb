require xorg-app-common.inc
PE = "1"

DEPENDS += " libxaw libxprintutil libxp libxt"


SRC_URI[archive.md5sum] = "c56160e93c24ddf17e69891ed50deb72"
SRC_URI[archive.sha256sum] = "2658d78bbaf8c9effac261f3c229c035fbfda817fa9636dea1e46078213362df"
