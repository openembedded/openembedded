require xorg-app-common.inc
DEPENDS += " libxprintutil libxp libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "e66f16684e92d3ca035c27003157cdbd"
SRC_URI[archive.sha256sum] = "2a13f97891a3fd497074acc8ac8069f8583add5db4d3bf34a5da6a92bd61b9e2"
