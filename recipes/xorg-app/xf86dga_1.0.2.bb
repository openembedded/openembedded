require xorg-app-common.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " virtual/libx11 libxxf86dga libxt libxaw libxmu"

