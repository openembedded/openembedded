require xorg-app-common.inc
DEPENDS += " libxaw libxprintutil libxp libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "f55e84713542a36887e966fc0648dd7b"
SRC_URI[archive.sha256sum] = "6cfe022c2ba42cd3f1acc64ead49f302f766b77f44a01ce3842ad25f62f65d8a"
