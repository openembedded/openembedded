require xorg-app-common.inc

DESCRIPTION = "Print out X-Video extension adaptor information"
DEPENDS += " libxv"
PE = "1"

SRC_URI[archive.md5sum] = "0a5bd8e43de6eb8ff5b5bc673204401d"
SRC_URI[archive.sha256sum] = "439b3c7ad96fc7b1ef9156c716e10b607883a9a58b777f8dc02f03284eb33fb3"
