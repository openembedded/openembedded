require xorg-app-common.inc
DEPENDS += " libxmu"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "e7f0d57b6ba49c384e9cf8c9ff3243c1"
SRC_URI[archive.sha256sum] = "bd8307272a648ca76a266e5c1111384c8ed9367c6a8f1a5be844a5b5300881a9"
