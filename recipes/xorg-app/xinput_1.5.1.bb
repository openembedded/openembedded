require xorg-app-common.inc

DESCRIPTION = "a utility to configure and test XInput devices"
DEPENDS += " libxi"
SRC_URI[archive.md5sum] = "82400f0ba63217df9b00d825532cea7d"
SRC_URI[archive.sha256sum] = "e33c8361c2b6cb13db9a7157753d417c168c8203c8b7027e9dda2fbeef00fd33"
