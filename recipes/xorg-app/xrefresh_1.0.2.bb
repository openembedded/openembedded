require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11"


SRC_URI[archive.md5sum] = "1228f890f86148e4e6ae22aa73118cbb"
SRC_URI[archive.sha256sum] = "522831fd29c0b250f29735a01b02e96e311f200a675e45c8b3d187b6f86b32f5"
