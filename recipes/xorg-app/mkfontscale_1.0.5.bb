require xorg-app-common.inc

DESCRIPTION = "a program to create an index of scalable font files for X"

DEPENDS += " zlib libfontenc freetype virtual/libx11"

SRC_URI[archive.md5sum] = "5e6e210b70adfef1264b0212aab1f758"
SRC_URI[archive.sha256sum] = "f79dff54153dc3beb9eb3f2e4776dbc55ed2a4d3d0adbf9c8a2d9eb230ed3850"
