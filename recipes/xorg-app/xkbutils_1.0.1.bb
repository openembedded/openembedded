require xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxaw libxkbfile virtual/libx11"


SRC_URI[archive.md5sum] = "84396a3dd75337caaae29d8fa5616fb1"
SRC_URI[archive.sha256sum] = "aaad73ed8db764978a18bc6ba774d38a4c1330c86622c0b47ae3ced09c175856"
