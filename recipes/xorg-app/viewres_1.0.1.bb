require xorg-app-common.inc
DEPENDS += " libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "cdbed540daf7975b56000420c9aa5bf9"
SRC_URI[archive.sha256sum] = "bf49cd45ffb197a6992b3b7c99c94161eaf7cf6a2b661d3905ac382bedce34b8"
