require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11 libfs"


SRC_URI[archive.md5sum] = "99144743ab3cbb9cf37090fdc9e747db"
SRC_URI[archive.sha256sum] = "690e45b252cd96036dd9b89af8624eb423e16d4bd662b07d264a3f876ce7ac22"
