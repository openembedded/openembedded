require xorg-app-common.inc

DESCRIPTION = "X server resource database utility"
LICENSE = "xrdb"
DEPENDS += "libxmu"
PE = "1"

SRC_URI[archive.md5sum] = "9c30b8e1709d5367beb7706146640c07"
SRC_URI[archive.sha256sum] = "c24d08939250f10238fd1b984707bfa0901ba9c55fa36b67d91eb12b500500aa"
