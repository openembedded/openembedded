require xorg-app-common.inc
DEPENDS += " libxt libxmu libxaw"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "9db49742bd4c17966fff7d76ac566d31"
SRC_URI[archive.sha256sum] = "978fbc134eef3da8a5f363c9e93494a3d7399e8f2b435ac6b1f2c63f09c167df"
