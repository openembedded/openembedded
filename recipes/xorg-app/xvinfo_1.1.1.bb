require xorg-app-common.inc
DESCRIPTION = "Print out X-Video extension adaptor information"
DEPENDS += " libxv"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "c88feb501083951a8f47a21aaeb1529d"
SRC_URI[archive.sha256sum] = "60c74aa190bcf1e244f6f1576dc43869018a8ed5ba319703a5c198d3466a3985"
