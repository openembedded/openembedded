require xorg-app-common.inc
PE = "1"

DEPENDS += " libxaw virtual/libx11 libxt libxmu"


SRC_URI[archive.md5sum] = "827a1ac5adf9aadd0c13b54a897e297b"
SRC_URI[archive.sha256sum] = "7156e58025e240a501d5b32244b923b283bb35014ea5a4081b70044af8aef7a3"
