require xorg-app-common.inc
DEPENDS += " libice xproxymngproto"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "0dbde8b3867032b9e4a383d46dfd7e48"
SRC_URI[archive.sha256sum] = "cdd6ecb453c62086dd01808a26787641add419dd42469349f79d0adeb89a6d93"
