require xorg-app-common.inc
DEPENDS += " libxau libxt libxext libxmu"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "033f14f7c4e30d1f4edbb22d5ef86883"
SRC_URI[archive.sha256sum] = "530902e8732130e37d9b46e73eecff90d6dbc5d5628620fded74a4e054aa8029"
