require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11 libxmu"


SRC_URI[archive.md5sum] = "dc8b420bbfa35091ea30edf57c952ec2"
SRC_URI[archive.sha256sum] = "d66cd7682e5ea2a52e8da8a75ea6154f40a3a69938c6c2cf5d5c1e012f5c121b"
