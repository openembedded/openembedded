require xorg-app-common.inc
PE = "1"

DEPENDS += " libxaw libxt"


SRC_URI[archive.md5sum] = "656bcbdd41818a8b5a9f7dba77a3eeba"
SRC_URI[archive.sha256sum] = "9471fb455ce0bfc582b865722ab7417c587c9fea82342181e9cd0a9629c2c6fa"
