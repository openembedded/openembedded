require xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " libxaw libxkbfile virtual/libx11"


SRC_URI[archive.md5sum] = "369a21641b7ca983d6641298e51d97f8"
SRC_URI[archive.sha256sum] = "12a37d4594a4deb2642b1659f3827068c24bb8791a20b927c5f3b7fdb0c70bee"
