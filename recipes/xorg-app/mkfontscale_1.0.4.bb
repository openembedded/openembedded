require xorg-app-common.inc

DESCRIPTION = "a program to create an index of scalable font files for X"

DEPENDS += " zlib libfontenc freetype virtual/libx11"

SRC_URI[archive.md5sum] = "e5d7373c4266973b3b13aac5d1a4655b"
SRC_URI[archive.sha256sum] = "dc9b946cc23490c960fbca8b32e4bba4bc23ce404a8d7e1c0e916894c83b4227"
