require xorg-app-common.inc

DESCRIPTION = "a utility to configure and test XInput devices"
DEPENDS += " libxi"

SRC_URI[archive.md5sum] = "3e8a5f1faccc8ab00c6190e5a34e0a45"
SRC_URI[archive.sha256sum] = "a84728e34bb5edd36ecc1b5489f48ad1467ad5aab1f74f1b7789f826a1ffcaf9"
