require xorg-app-common.inc
DEPENDS += " virtual/libx11 libxmu xbitmaps libxt"
PE = "1"

SRC_URI[archive.md5sum] = "98200c358e5401d648b980564d9ae39d"
SRC_URI[archive.sha256sum] = "863f673518af19f9ae35ee221b30bf8c8b695c76c543d18b3ac400a51b855c41"
