require xorg-app-common.inc
DEPENDS += " libxaw libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "fec79887ca14575bef4c757b4e95a693"
SRC_URI[archive.sha256sum] = "fed1be13409b6963d88ee668da4670cd6da5bd9aff95576234df8849e2084002"
