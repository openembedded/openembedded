require xorg-app-common.inc
DESCRIPTION = "server font list displayer for X"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "bf6f3e7074479839d5182ffed735d2be"
SRC_URI[archive.sha256sum] = "b59358b664f8220e3856d01d6b3e60adcc70f04fc588d71e0f7d9fd35e0e67c2"
