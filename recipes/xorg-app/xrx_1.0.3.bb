require xorg-app-common.inc
PE = "1"

DEPENDS += " libxaw virtual/libx11 libxt libxext xtrans xproxymngproto libxau"


SRC_URI[archive.md5sum] = "c121945afcfc84e99af17158fda68be9"
SRC_URI[archive.sha256sum] = "9cb0fc67153ce935550d61dfd3d021cb3e6833274453538885b7cddff9fe8abe"
