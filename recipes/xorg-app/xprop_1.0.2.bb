require xorg-app-common.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " libxmu virtual/libx11"


SRC_URI[archive.md5sum] = "5b6f02a3b1cda0cadc35f84814fe53d4"
SRC_URI[archive.sha256sum] = "88b1e65703c68f14ac6cb735737d1a0e52751a18fdc8a39d2d1e5eaa07875ca0"
