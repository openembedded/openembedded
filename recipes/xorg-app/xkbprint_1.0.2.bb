require xorg-app-common.inc
PE = "1"

DEPENDS += " libxkbfile virtual/libx11"


SRC_URI[archive.md5sum] = "3d3eb10466442354d6b73b503b9829db"
SRC_URI[archive.sha256sum] = "2e51b3c2d33da885be6d955007ae7e025b8f8b21f7fe6d21387690d9f5cadb92"
