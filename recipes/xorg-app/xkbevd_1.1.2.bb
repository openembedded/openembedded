require xorg-app-common.inc
DEPENDS += " libxkbfile "
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "d8d0bc5935b4b8f016ed92fd369dd385"
SRC_URI[archive.sha256sum] = "cd62946c9feb3eb2fe0baef1ce5c0f4ab14148099264ecbce6e039b17880eb63"
