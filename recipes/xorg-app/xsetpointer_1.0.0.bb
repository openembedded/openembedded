require xorg-app-common.inc
PE = "1"

DEPENDS += " libxi virtual/libx11"


SRC_URI[archive.md5sum] = "c94ea103e27e370e4e5030e50c5d5d69"
SRC_URI[archive.sha256sum] = "7d65f450420b4f764dcf38e4ccee9d608b5a5874706e716cb861bfe2586b7d4a"
