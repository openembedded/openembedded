require xorg-app-common.inc
PE = "1"

DEPENDS += " libxaw xbitmaps libxext"


SRC_URI[archive.md5sum] = "1d4ad06725f9dc4b877ecd210b7b1607"
SRC_URI[archive.sha256sum] = "7c21763a90599ad627739804ba76dd33516b76cce440294e1154bf680eca60f7"
