require xorg-app-common.inc
PE = "1"

DESCRIPTION = "X Session Manager"

DEPENDS += " libxaw libxt"


SRC_URI[archive.md5sum] = "cce867ff7d0df9c0b9e682591779952c"
SRC_URI[archive.sha256sum] = "2f2535b5394d59be0a4bb15c12ea1b19b873a0096446ecc4c71aa81f0d99b29a"
