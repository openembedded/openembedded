require xorg-app-common.inc
DEPENDS += " xcb-util"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "6d42621616da0c720f640d23873604ce"
SRC_URI[archive.sha256sum] = "453b5e13a61d4b2a2a52ba75d529c5d761bbb65ecd65fe5b7b0121402a0be859"
