require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11 libxmu"


SRC_URI[archive.md5sum] = "f66d76abb0f75514ca32272e23cca757"
SRC_URI[archive.sha256sum] = "77a11aac6e4ae2132d8b7b4335be77de26655e6aa88b40e51fd2ee802f14a9de"
