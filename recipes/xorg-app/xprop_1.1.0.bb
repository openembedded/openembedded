require xorg-app-common.inc
DESCRIPTION = "a property displayer for X"
DEPENDS += " libxmu "
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "f0bacbd30f0dd1c1e9ccafe97687b7a4"
SRC_URI[archive.sha256sum] = "cc8e07901574895f113baffda19272c54545879e02012314527ebbf2dcc66226"
