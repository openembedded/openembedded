require xorg-app-common.inc
PE = "1"

DEPENDS += " libxmu virtual/libx11"


SRC_URI[archive.md5sum] = "01c0a14755fc91369e8c011c9f881d5d"
SRC_URI[archive.sha256sum] = "b871221d23dc4fc50398e9fe0e2a6a4e951aa6c9df2c5671d069ad88f0fd6249"
