require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11 libfs"


SRC_URI[archive.md5sum] = "e98b18fbce1261de30b1de819d86f48a"
SRC_URI[archive.sha256sum] = "adc33443b3a7f334d2407de702004a0491f24708e0e1abe74cd8ae114cd60cd9"
