require xorg-app-common.inc
DESCRIPTION = "analog / digital clock for X"
DEPENDS += " libxaw libxrender libxft libxkbfile libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "eaf124bbc9d13e1a12a29faaa2ed3612"
SRC_URI[archive.sha256sum] = "53a9169e24f3814fbfcfee3ca0b98637840a3156ed7c7e36ae03940fabae4c9a"
