require xorg-app-common.inc

#DESCRIPTION = ""

DEPENDS += " virtual/libx11"

SRC_URI[archive.md5sum] = "ca9c6c88d0b83360b7b5092615fbf591"
SRC_URI[archive.sha256sum] = "c8d826194299b2b8e3c6edce7070f05421465b0118ed47135a0195d12fe8a720"
