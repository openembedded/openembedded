require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11 libxaw libxrender libxft libxkbfile libxt"

