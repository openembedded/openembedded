require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11 libxt libxmu libxaw"


SRC_URI[archive.md5sum] = "a25f931cc6c8d03daaed434f5db5df2d"
SRC_URI[archive.sha256sum] = "a2a56b32eaa92ad6f667853f023177ffad9128cfa0361afc2872323598aeceae"
