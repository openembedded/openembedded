require xorg-app-common.inc
PE = "1"

DEPENDS += " libxkbfile virtual/libx11"


SRC_URI[archive.md5sum] = "8d3c1485c2dd62ea7395a37377958a39"
SRC_URI[archive.sha256sum] = "46037add20321ff13954ad91aa5f5f5ec52d78006f9d7c52aa6167622b34a2df"
