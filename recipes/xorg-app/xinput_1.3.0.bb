require xorg-app-common.inc

DESCRIPTION = "a utility to configure and test XInput devices"
DEPENDS += " libxi"

SRC_URI[archive.md5sum] = "977d657e8d7b59f7d82c98ebef444b28"
SRC_URI[archive.sha256sum] = "330c3e5188abf256131c162c456060804f369349e9a0e7aa3efbc54add802e45"
