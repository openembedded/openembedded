require xorg-app-common.inc
DESCRIPTION = "query configuration information of DRI drivers"
DEPENDS += " virtual/libx11 glproto virtual/libgl"
PE = "1"

SRC_URI[archive.md5sum] = "cb304d1ce562ac48b68eedeba38c662f"
SRC_URI[archive.sha256sum] = "2b762afd08c798d79fd6dacfd6280da39105927fa2bd91e3b1ba75b8cddc259c"
