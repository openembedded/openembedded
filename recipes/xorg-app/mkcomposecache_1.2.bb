require xorg-app-common.inc

DESCRIPTION = "used for creating global (system-wide) Compose cache files"

SRC_URI[archive.md5sum] = "c8237b4aea1ae0c15441deab6b12c5c0"
SRC_URI[archive.sha256sum] = "8c34cdd03f7d11ac86c681349d39a4faf88854faaad928f0663da55f125aedfb"
