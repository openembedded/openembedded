require xorg-app-common.inc
DESCRIPTION = "create an X cursor file from a collection of PNG images"
DEPENDS += " virtual/libx11 libxcursor libpng"
PE = "1"

SRC_URI[archive.md5sum] = "6fc90896b8c786cb1a2100b4167f7874"
SRC_URI[archive.sha256sum] = "e009322bd2afef8d4ad91bcb6b17874e1cd00b1aaf397e7019a82cc44f3c174e"
