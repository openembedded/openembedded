require xorg-app-common.inc
PE = "1"

DEPENDS += " libxi virtual/libx11"


SRC_URI[archive.md5sum] = "d074e79d380b031d2f60e4cd56538c93"
SRC_URI[archive.sha256sum] = "988b47cd922991c6e6adbce15dc386ac75690b61744b526c3af5a4eaa9afa0aa"
