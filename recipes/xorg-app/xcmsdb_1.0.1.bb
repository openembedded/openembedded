require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11"


SRC_URI[archive.md5sum] = "8579d5f50ba7f0c4a5bf16b9670fea01"
SRC_URI[archive.sha256sum] = "e275a39f41ffae854db77b2c5decfad2cac32afbcd158842032dc9ca04efe92e"
