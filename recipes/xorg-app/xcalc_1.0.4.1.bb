require xorg-app-common.inc
DESCRIPTION = "scientific calculator for X"
DEPENDS += " libxaw libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "052c59f7d917b1302e7142bbd888d808"
SRC_URI[archive.sha256sum] = "e21f3b09a5ffdaafced32fdccd94d48351c95e5f8a2d7cb036d61dd18f4e26b6"
