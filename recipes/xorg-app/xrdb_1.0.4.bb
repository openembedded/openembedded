require xorg-app-common.inc

DESCRIPTION = "X server resource database utility"
LICENSE = "xrdb"
DEPENDS += "libxmu"
PE = "1"

SRC_URI[archive.md5sum] = "34eb2311a0c5279e7b4f492e826f63d1"
SRC_URI[archive.sha256sum] = "3f8cde77e8cbeb6d0a5f232b7a2ee51dd49b677916d52ab0986d320a5f9e8000"
