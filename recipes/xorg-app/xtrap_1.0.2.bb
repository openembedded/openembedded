require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11 libxtrap"


SRC_URI[archive.md5sum] = "97a62a011a11f03b46d72851aa298fa8"
SRC_URI[archive.sha256sum] = "8f513da45b0c65dff4a3d477e5600a98d677571d7ed283f52c905987dcae0fbc"
