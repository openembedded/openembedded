require xorg-app-common.inc
DEPENDS += " libxkbfile "
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "b98ae2d8b21c545b7b322d0b302efefa"
SRC_URI[archive.sha256sum] = "008dffea5b213880cb3ebd40d0b9bf0cc10392fb0349831efdebf2a428dd2e17"
