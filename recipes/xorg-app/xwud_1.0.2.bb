require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11"


SRC_URI[archive.md5sum] = "20bc5d85634964d4ceee77cdfcd131ed"
SRC_URI[archive.sha256sum] = "84345dfbff0dc411689639aada2407758640af71eb61a1be332bfa24d8b90ac1"
