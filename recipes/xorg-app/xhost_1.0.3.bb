require xorg-app-common.inc

DESCRIPTION = "Server access control program for X"
LICENSE = "MIT"
DEPENDS += "libxmu libxau"
PE = "1"

SRC_URI[archive.md5sum] = "c7f91b4a750d297f269c2a0a3206a1b2"
SRC_URI[archive.sha256sum] = "2d63007c65e89fe273a43f3e45b3c0133acbc3ceeda6bfc9671388409134ad17"
