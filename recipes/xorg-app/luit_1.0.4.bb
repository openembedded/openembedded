require xorg-app-common.inc
DESCRIPTION = "a filter for locale and ISO 2022 support on Unicode terminals"
DEPENDS += " zlib zlib virtual/libx11 libfontenc"
PE = "1"

SRC_URI[archive.md5sum] = "4e45233e310d72dce307709761cf241b"
SRC_URI[archive.sha256sum] = "d11cd500975f652060f89d79cb8034011d99ee9aa6c82951680fc0621ecb8252"
