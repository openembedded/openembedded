require xorg-app-common.inc

DESCRIPTION = "point and click selection of X11 font names"
DEPENDS += " libxaw"

SRC_URI[archive.md5sum] = "288fe4cf8a990e4e602aac16dd9109fb"
SRC_URI[archive.sha256sum] = "7a66ba3910bd7e39d58f9d4a4a588f191a874b8607369fe2cc9203a7115006a9"
