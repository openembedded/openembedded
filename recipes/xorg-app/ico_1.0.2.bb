require xorg-app-common.inc
PE = "1"

DESCRIPTION = "an X graphics demo using an animated polyhedron"

DEPENDS += " virtual/libx11 libxau libxdmcp"

SRC_URI[archive.md5sum] = "5711827c5c2563620b56c33aababbc63"
SRC_URI[archive.sha256sum] = "db2e96e18a2bcc29b91b9de7b758a7c67cebee27772fb540c44c7bc2c2218aa5"
