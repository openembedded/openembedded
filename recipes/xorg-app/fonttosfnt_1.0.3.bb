require xorg-app-common.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " xproto freetype libfontenc"

