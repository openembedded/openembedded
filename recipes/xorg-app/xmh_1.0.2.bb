require xorg-app-common.inc
DEPENDS += " libxaw libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "f5956a63c3d4d4b004b73e8be64d6d6e"
SRC_URI[archive.sha256sum] = "5bbb6d580d148def32b17faa85012995ceac7d451a65d392adc3e4b439915720"
