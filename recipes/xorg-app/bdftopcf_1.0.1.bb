require xorg-app-common.inc
PE = "1"

DESCRIPTION = "converts BDF fonts to PCF fonts"

DEPENDS += " libxfont"


SRC_URI[archive.md5sum] = "9685fab33d39954ab8a0d22e0969d5a4"
SRC_URI[archive.sha256sum] = "aaaa45ab361781aebda2093fdc7eb5c187f6215b4ba308dd6b9ff2b727e805d3"
