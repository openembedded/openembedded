require xorg-app-common.inc
DESCRIPTION = "system load average display for X"
DEPENDS += " libxaw libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "5f6e8c54da51ad0e751abf54980b0ef1"
SRC_URI[archive.sha256sum] = "ffdcc2862ad4da46506080983b9d8d25343da9e34c38ceb63180674bb5730bf2"
