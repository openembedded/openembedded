require xorg-app-common.inc
DESCRIPTION = "magnify parts of the screen"
DEPENDS += " libxaw libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "2a76128511214bde973258baef537be3"
SRC_URI[archive.sha256sum] = "6eb02bafb5a5b1d8a92c716d37dd7698a72523cadd8ab0869f0a7eb11b4189a6"
