require xorg-app-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "2f63f88ad0dcecd33c8cf000f38e9250"
SRC_URI[archive.sha256sum] = "069502eb485ea128a0bebf94302d5cbb271ad9d31ae51691abd6d64914ff9d7b"
