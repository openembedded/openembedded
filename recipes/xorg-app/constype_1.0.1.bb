require xorg-app-common.inc

DESCRIPTION = "print an X window dump"
DEPENDS += " libxmu virtual/libx11"
PE = "1"

SRC_URI[archive.md5sum] = "9f99bee77ff3c565b4898663810fbef5"
SRC_URI[archive.sha256sum] = "11403054cb407cdf31da48216f55d1b5943798cb442bcab69faa0a3d7d167541"
