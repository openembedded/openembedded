require xorg-app-common.inc
DEPENDS += " libxmu"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "dca031355b4afcf8517a8258eeb730c3"
SRC_URI[archive.sha256sum] = "532df0398d3f4eab1cba8d0367c02a293ca74f2d89a27ef014854a2bde9a5a27"
