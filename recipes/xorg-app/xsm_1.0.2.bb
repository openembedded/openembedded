require xorg-app-common.inc
DESCRIPTION = "X Session Manager"
DEPENDS += " libxaw libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "521d2a34c6dbc0700f489290d51b0b67"
SRC_URI[archive.sha256sum] = "cdb733ef2508aecdd21edf6e394ddff8c4ac99f7659f65210548b69ef54c2b57"
