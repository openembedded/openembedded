require xorg-app-common.inc
DESCRIPTION = "utility for modifying keymaps and pointer button mappings in X"
LICENSE = "MIT"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "b18850d373f3717dca569377c449d091"
SRC_URI[archive.sha256sum] = "421ee7a17b0cf559c4901225f70c497e3c5ca205ec7dcc84712055818d2f3402"
