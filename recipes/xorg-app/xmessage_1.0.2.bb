require xorg-app-common.inc

DESCRIPTION = "xmessage displays a message or query in a window."
DEPENDS += " libxaw libxt"
PE = "1"

SRC_URI[archive.md5sum] = "b4b561ef11fd184989a6062962e86748"
SRC_URI[archive.sha256sum] = "02b4016e93acab94105fa61f6dbe13082669276ab4650b871835fb7884b0c3c3"
