require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11 libfs"


SRC_URI[archive.md5sum] = "e6c0071f6d5436113982f4a575d3f94b"
SRC_URI[archive.sha256sum] = "95aaca84f948fc7e25d82c58d3fdbba44911b99f3e205378ce82a786c11bb96f"
