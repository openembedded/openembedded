require xorg-app-common.inc

DESCRIPTION = "Sets the visual appearance of the X root window"
LICENSE = "MIT"
DEPENDS += "libxmu xbitmaps"
PE = "1"

SRC_URI[archive.md5sum] = "cbda9b9b8da5af4614110883d5a276b8"
SRC_URI[archive.sha256sum] = "d7e512cc686de3ab5fcd3c9f9e605d7cae68a4b50f2c0786f0f09ce08c728f48"
