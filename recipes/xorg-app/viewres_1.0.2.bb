require xorg-app-common.inc
PE = "1"

DEPENDS += " libxt"


SRC_URI[archive.md5sum] = "f35c4ad7e1aa1ee2b25373dcdc34345b"
SRC_URI[archive.sha256sum] = "85c7207f89bfb13cc9f3c3c9d9a785094e7576e5e3e7ef0450544c4cd6bbbf3b"
