require xorg-app-common.inc
DEPENDS += " libxscrnsaver libxt libxaw libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "8bc2e35cdcd2e6a80eab1b77c41f2a46"
SRC_URI[archive.sha256sum] = "00e217559c93779fe04fd948017820af118a3981d6b4371ace95107cb3b047a7"
