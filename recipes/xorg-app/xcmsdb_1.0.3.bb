require xorg-app-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "a8f013229f7234d582e0ee2c89879e30"
SRC_URI[archive.sha256sum] = "b237d060f1eed71fa2bfe089b7fb04508299e1a49091a7d7b0e536f8344d5a80"
