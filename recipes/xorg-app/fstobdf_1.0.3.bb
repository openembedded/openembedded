require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11 libfs"


SRC_URI[archive.md5sum] = "49a6225380f6c18fff664a043cd569b1"
SRC_URI[archive.sha256sum] = "f2242720045c69f69dc9e18320a1c6402e92234d40c237367560fae3d210f7b0"
