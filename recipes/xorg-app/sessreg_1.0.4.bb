require xorg-app-common.inc
PE = "1"

DESCRIPTION = "a simple program for managing utmp/wtmp entries"

DEPENDS += " virtual/libx11"


SRC_URI[archive.md5sum] = "839e968d7197b9563f0fd8a5a3aac2e3"
SRC_URI[archive.sha256sum] = "23e163502e208ac16f04a12b15f7f8dcd9919f0149c714353b7f92539b7e9802"
