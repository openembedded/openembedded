require xorg-app-common.inc
DEPENDS += " libfs"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "50b466ab6ed4a5b8df5abf1ef844309a"
SRC_URI[archive.sha256sum] = "2a9db9b21be37653e534a6cc5facceacf7a1493d3278ef54817f23b070dc0c7e"
