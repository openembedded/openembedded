require xorg-app-common.inc
PE = "1"

DEPENDS += " libxkbfile virtual/libx11"


SRC_URI[archive.md5sum] = "68f2a143716c23b566f8509d9498f516"
SRC_URI[archive.sha256sum] = "4b78e316ecf9a9498291f634a7e9ee712ba429d5606f300c0a27eacdaaa1f72b"
