require xorg-app-common.inc
DEPENDS += " libxprintapputil libxaw libxprintutil libxt libxp"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "5c7fd1e35dd63089229e357c46e4f407"
SRC_URI[archive.sha256sum] = "b1ca08e3ba4e5b135ee9d8675e717a6f88eafa53b031b2b821d2760897e35426"
