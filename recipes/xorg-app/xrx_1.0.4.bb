require xorg-app-common.inc
DEPENDS += " libxaw libxt libxext xtrans xproxymanagementprotocol libxau"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "c93be22d20658ac5ff60469207dec118"
SRC_URI[archive.sha256sum] = "b5eb5ecae105ed4d3b2c91193a1c2ef9fe51b1145190541a59f92645899763a4"
