require xorg-app-common.inc

DESCRIPTION = "Server access control program for X"
LICENSE = "MIT"
DEPENDS += "libxmu libxau"
PE = "1"

SRC_URI[archive.md5sum] = "f746aba36f075ae4cae313d849a94f4e"
SRC_URI[archive.sha256sum] = "edab2cc49d230f58e54c0f7b83fd726fec5fc31356668a11589649f19ba90db6"
