require xorg-app-common.inc
PE = "1"

DESCRIPTION = "xmessage displays a message or query in a window."

DEPENDS += " libxaw libxt"

