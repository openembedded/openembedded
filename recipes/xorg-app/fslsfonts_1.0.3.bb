require xorg-app-common.inc
DEPENDS += " libfs"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "9b50d967ac6d4bae9bffb62a5e527a50"
SRC_URI[archive.sha256sum] = "9d5739a2649cbade55c9f5725a3a052253d748d868ddd03f2c036fef2ffe96bc"
