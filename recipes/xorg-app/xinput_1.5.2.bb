require xorg-app-common.inc
DESCRIPTION = "a utility to configure and test XInput devices"
DEPENDS += " libxi"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "8cec6023f90180cb8e4be31d98c43fda"
SRC_URI[archive.sha256sum] = "2ce78601dc9289515749ef11d3af9d09d68c93f3efe69701112e95dd0da76390"
