require xorg-app-common.inc
PE = "1"

DEPENDS += " libxaw virtual/libx11 libxt libxmu"


SRC_URI[archive.md5sum] = "3c0d5d8d6abaf411cd0647bc7073ac38"
SRC_URI[archive.sha256sum] = "4d9e24b95619bc961936d241106ffcc483995de55629567113ad78ba0b37ffb7"
