require xorg-app-common.inc
DEPENDS += " libxaw xbitmaps libxext libxmu"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "f38a0c63c2a7ed6fb9d6f8884785b5c9"
SRC_URI[archive.sha256sum] = "aa1db4f31f7afcfe131bda7ff6e380ff7de41cf1a7009464783043c817c47ce8"
