require xorg-app-common.inc
DESCRIPTION = "analog / digital clock for X"
DEPENDS += " virtual/libx11 libxaw libxrender libxft libxkbfile libxt"
PE = "1"

SRC_URI[archive.md5sum] = "bb9fd5e00d39c348a0078b97fdf8258f"
SRC_URI[archive.sha256sum] = "69b903b6305211c9fc5db394f3d08c0a696aa51942d73db7f594422e7be6edf0"
