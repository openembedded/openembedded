require xorg-app-common.inc
DEPENDS += " libxt libxmu libxaw"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "1800dda934ebb7c588ea686278a10e9f"
SRC_URI[archive.sha256sum] = "d7ce4c0bb214e055cb7680d8b88b9f551610fc40c28269cb51649133862f3302"
