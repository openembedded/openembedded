require xorg-app-common.inc
DEPENDS += " libxmu "
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "007cea1f389abde5c93162dcd5541351"
SRC_URI[archive.sha256sum] = "fff2dbea086c554463d4309209ee05e026b7f19900598f55e0a24a6d7a7ee3fd"
