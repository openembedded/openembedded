require xorg-app-common.inc
DESCRIPTION = "monitor system console messages with X"
DEPENDS += " libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "8665c037032e5f6a3acd4b341749aa17"
SRC_URI[archive.sha256sum] = "5643e90bf7bf77369e67f3a0a982a4809b5bd2d9a36f02a59c79de77c9d6648e"
