require xorg-app-common.inc
DEPENDS += " libfs"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "fc1f42aac16d6b76c79a1a3a0fb6a53b"
SRC_URI[archive.sha256sum] = "f1ca8af634656d727d09cc7527f02ba2655eb7a8c217bde36cd44701665ee06b"
