require xorg-app-common.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " xproto freetype libfontenc"


SRC_URI[archive.md5sum] = "07607b26fce3bdc2b204ff3bc43d3ac3"
SRC_URI[archive.sha256sum] = "3feaaab499b3f9c7e9b8bdc725dd40fde65b2fbb73794845d7f682746470f594"
