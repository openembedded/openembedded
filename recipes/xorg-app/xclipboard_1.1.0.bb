require xorg-app-common.inc
DEPENDS += " libxaw libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "113eccea3ee73a1ef7b43d2291ca1e09"
SRC_URI[archive.sha256sum] = "de0f37c7bf69c3aac3362bc0cbe470a622c2a85b62c5483c113ea88512232710"
