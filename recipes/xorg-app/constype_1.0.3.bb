require xorg-app-common.inc
DESCRIPTION = "print an X window dump"
DEPENDS += " libxmu "
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "7347bb324e3095f8791386b8154edc11"
SRC_URI[archive.sha256sum] = "41151d05e878d6102eba65ce750de184e183fd2e6db9acba486accae44ce366a"
