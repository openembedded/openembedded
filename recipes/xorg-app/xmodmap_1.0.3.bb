require xorg-app-common.inc

DESCRIPTION = "utility for modifying keymaps and pointer button mappings in X"
LICENSE = "MIT"
PE = "1"

SRC_URI[archive.md5sum] = "626731003ec22a74ecf9e44ed098bbdf"
SRC_URI[archive.sha256sum] = "c3bfc724792858222c138c1ae9a017e69e7d3bdda3fc9f5da38b232ab031147f"
