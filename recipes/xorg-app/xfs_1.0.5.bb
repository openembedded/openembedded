require xorg-app-common.inc

DESCRIPTION = "X fontserver"
DEPENDS += " libfs libxfont xtrans"
PE = "1"

SRC_URI[archive.md5sum] = "3fc73b5e39a1fe8b8d96563c8144cffe"
SRC_URI[archive.sha256sum] = "f586f2101d42e512e7d20a6a6715c3c2cad19cacbee3b4034a0818de349e38f9"
