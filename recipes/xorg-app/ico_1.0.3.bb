require xorg-app-common.inc
DESCRIPTION = "an X graphics demo using an animated polyhedron"
DEPENDS += " libxau libxdmcp"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "9574a53c122b3a6e85bbf3476ebf8ee8"
SRC_URI[archive.sha256sum] = "db00f97a19e7ff87065f70df0a347a4924815cba7bceef801456d9180a3fd896"
