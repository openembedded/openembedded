require xorg-app-common.inc
DEPENDS += " libxxf86dga libxt libxaw libxmu"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "865a17eb6fe8892e58bb1bdb35f059df"
SRC_URI[archive.sha256sum] = "b4d87411049d5edb6f33b7e57bceb5a07e41ec5c48900aef492fb0ff74e6a252"
