require xorg-app-common.inc

DESCRIPTION = "used for creating global (system-wide) Compose cache files"

SRC_URI[archive.md5sum] = "25b774e1b64833d0cdc00663931efc73"
SRC_URI[archive.sha256sum] = "c9ee54d18cb9a8a0c5fcd8d2dd08ed8ed869f3a538af46caff08ca9bc9cf2caf"
