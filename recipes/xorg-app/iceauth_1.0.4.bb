require xorg-app-common.inc
DESCRIPTION = "a tool for manipulating ICE protocol authorization records"
DEPENDS += " libice"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "bb2e4d2611047f7c5a1a82ec956a9de4"
SRC_URI[archive.sha256sum] = "0ee6fd4554f0131b1ed526ee00b9cf643e7dc97eb70fb51448848ef2f349938d"
