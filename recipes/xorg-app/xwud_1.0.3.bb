require xorg-app-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "a37020053e8ee32c6fd1145242d53ee3"
SRC_URI[archive.sha256sum] = "88fdeae05cc3bcc35dfbf0df1606bc4ed4a420edb1abf96aececbc1bd7332c43"
