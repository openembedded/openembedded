require xorg-app-common.inc

DESCRIPTION = "print an X window dump"
DEPENDS += " libxmu virtual/libx11"
PE = "1"

SRC_URI[archive.md5sum] = "6b3a6896081f628bf5a2c9129417c86f"
SRC_URI[archive.sha256sum] = "c325a9896d1cda43a681f1c2a6a2bbb1c580ade57a882b0a8f84ffa359238adf"
