require xorg-app-common.inc
DEPENDS += " libxcb"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "c543ccb6489b629d427810d9a57d0724"
SRC_URI[archive.sha256sum] = "4a017ada25140a71034fc0026500ebe24b81f2d185a4b2ef733de683b79dcb0d"
