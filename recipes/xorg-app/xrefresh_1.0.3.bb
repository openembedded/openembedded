require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11"


SRC_URI[archive.md5sum] = "8f4fafcfb77b3c6972cc44bb3f1c899c"
SRC_URI[archive.sha256sum] = "3ee0a5f7aeb14bbffbcafcff8e7806c9a59f08e1a58322a50f5fca023a7d7ed9"
