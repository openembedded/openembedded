require xorg-app-common.inc
PE = "1"

DESCRIPTION = "The appres program prints the resources seen by an application."

DEPENDS += " virtual/libx11 libxt"


SRC_URI[archive.md5sum] = "420e6cdf38bb771ec8b00228bf09e8ff"
SRC_URI[archive.sha256sum] = "15fef83a202b8dcee3420c88dba4aeed1f8fc840ab537487fb5411b99a2eb962"
