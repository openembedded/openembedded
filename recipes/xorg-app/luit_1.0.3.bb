require xorg-app-common.inc
DESCRIPTION = "a filter for locale and ISO 2022 support on Unicode terminals"
DEPENDS += " zlib zlib virtual/libx11 libfontenc"
PE = "1"

SRC_URI[archive.md5sum] = "b01e4f71c20fc1c79ed727759c1df40c"
SRC_URI[archive.sha256sum] = "2010f2152eee89a67f02edc3041574fb07442d075ca46fbcf84f981f0977a5d7"
