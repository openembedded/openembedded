require xorg-app-common.inc

DESCRIPTION = "server font list displayer for X"
DEPENDS += " virtual/libx11"

SRC_URI[archive.md5sum] = "28958248590ff60ecd70e8f590d977b7"
SRC_URI[archive.sha256sum] = "cc6e519b783b082a2fe4cd06ea5b3693ee6bdb23f4b36e7a72753c524ef5111c"
