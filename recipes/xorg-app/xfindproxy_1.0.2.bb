require xorg-app-common.inc
DEPENDS += " libxaw libxt xproxymanagementprotocol"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "2fa74c68511ae845f52c2f33e641d0fd"
SRC_URI[archive.sha256sum] = "a83b5c197ce13a52f021f0d00470e70a1c32d8e93244156c677729a7a5e15bb2"
