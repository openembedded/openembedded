require xorg-app-common.inc
PE = "1"

DESCRIPTION = "a property displayer for X"

DEPENDS += " libxmu virtual/libx11"

SRC_URI[archive.md5sum] = "48aa8fd78802f477dcbf9ef0dfd9f783"
SRC_URI[archive.sha256sum] = "daa47cba7d5a919ca1bd053d8a8b6af4904f77eded4bdb055cd915aa5f5cd772"
