require xorg-app-common.inc
PE = "1"

DEPENDS += " libxmu virtual/libx11"


SRC_URI[archive.md5sum] = "911addfb7fa402217ddac63e5c1d97c7"
SRC_URI[archive.sha256sum] = "c8bd9bcd64df439c2cd09eaa3e83a1297fbfed5c7d3dd8117342b3a25eeae131"
