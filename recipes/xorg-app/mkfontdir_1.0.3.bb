require xorg-app-common.inc

PE = "1"

RDEPENDS += "mkfontscale"

