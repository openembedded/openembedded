require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11"



SRC_URI[archive.md5sum] = "08c7f078fc351196c21db3a8206d482d"
SRC_URI[archive.sha256sum] = "1b154b4359302ca499818c45396325aef9ff364d6ff4ce5c3769e4803994a136"
