require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11"


SRC_URI[archive.md5sum] = "7f2bed9f4dd3301d18d83eb296c3be0d"
SRC_URI[archive.sha256sum] = "bfcac66634ea4d4a1607f1c8a4170e6089db13355357fc143281a6fc0216face"
