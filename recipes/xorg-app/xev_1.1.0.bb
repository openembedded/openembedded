require xorg-app-common.inc
DESCRIPTION = "X Event Viewer"
LICENSE = "MIT"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "515cfd1fe857b66abe43ec3343634954"
SRC_URI[archive.sha256sum] = "3859c268edb26ad0484281a244a567ef2f70ba5f91f4b5dfd37799255ccf01c6"
