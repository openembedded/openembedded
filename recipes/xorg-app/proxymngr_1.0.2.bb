require xorg-app-common.inc
DEPENDS += " libice libxt xproxymanagementprotocol"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "714c4656e749ce856690b872e3d4ac4c"
SRC_URI[archive.sha256sum] = "c16aa5137476d7285785e2a51e216a0df7a292daa4c206deedb16641ddeeb000"
