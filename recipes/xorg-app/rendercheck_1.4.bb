require xorg-app-common.inc
DESCRIPTION = "a program to test Render extension implementations"
DEPENDS += "libxrender"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "d0e7541004b9a1d8210a63fffebac139"
SRC_URI[archive.sha256sum] = "6835ce19788e2e9b9ac0307b92adac88daee57edd56e0739c822a0811bc83b87"
