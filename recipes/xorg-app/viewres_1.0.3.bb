require xorg-app-common.inc
DEPENDS += " libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "c9d15462c0190dce61d04a6717dd7622"
SRC_URI[archive.sha256sum] = "1ad506fa0a01afeb914d05d58c5c9ff46f0348093dab646a30bbdcf727eede0a"
