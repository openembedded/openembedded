require xorg-app-common.inc

DESCRIPTION = "a program to test Render extension implementations"
DEPENDS += "libxrender"

SRC_URI[archive.md5sum] = "eb6a358b79b0aeaf03d56c5e1f394365"
SRC_URI[archive.sha256sum] = "60e83bebab37c2754ae77cc359c0b67e8bc72b46821c7fa260ccc5c811bd741f"
