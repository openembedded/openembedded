require xorg-app-common.inc
DEPENDS += " libxmu libxext libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "353d939113901ea3cdcf1c0369b522e4"
SRC_URI[archive.sha256sum] = "5d22af9fe0bb65d3a1b526b7ed3c681ce528f9d22325a6164ea57b65dbea84a6"
