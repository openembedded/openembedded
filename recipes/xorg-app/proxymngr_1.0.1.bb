require xorg-app-common.inc
PE = "1"

DEPENDS += " libice libxt virtual/libx11 xproxymngproto"


SRC_URI[archive.md5sum] = "aad44d0f65b97fd6d564b1d2ae510bb1"
SRC_URI[archive.sha256sum] = "e9f5d4553411562477a0605fb0f0ec728016499e37230138a5e207dec79525c5"
