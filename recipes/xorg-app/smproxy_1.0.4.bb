require xorg-app-common.inc
DEPENDS += " libxt libxmu"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "8ab518393bef44d3ea2bccb027021aab"
SRC_URI[archive.sha256sum] = "3792e5772f74ac4a1bcb1d3feee2f899b24ffa958250ed6f9944269d15f94472"
