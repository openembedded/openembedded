require xorg-app-common.inc
DESCRIPTION = "query configuration information of DRI drivers"
DEPENDS += " virtual/libx11 glproto virtual/libgl"
PE = "1"
PR = "r1"

SRC_URI[archive.md5sum] = "a5ec51ed9f0a55dc3462d90d52ff899c"
SRC_URI[archive.sha256sum] = "7b03ac095b6c79688c20ad61e3576d4698e3f16c09a7f3f1e7c50826814e7265"
