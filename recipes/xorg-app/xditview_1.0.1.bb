require xorg-app-common.inc
DEPENDS += " libxaw libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "e9a7192ef29453b8c810ddd556a463c0"
SRC_URI[archive.sha256sum] = "177194e5f83b31c2f934e3a0b573e8ae359edf2ef1a2403ee8e1dad383558117"
