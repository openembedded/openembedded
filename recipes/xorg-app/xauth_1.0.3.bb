require xorg-app-common.inc

DESCRIPTION = "X authority file utility"
DEPENDS += "libxau libxext libxmu"
PE = "1"

SRC_URI[archive.md5sum] = "e91e10ace1df0d5f2cbc74ead256407a"
SRC_URI[archive.sha256sum] = "1fd18b53fda74ea4649eb9577b1cf86538a25d171f10251eeb30d11cdd5bda8c"
