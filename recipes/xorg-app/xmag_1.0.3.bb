require xorg-app-common.inc

DESCRIPTION = "magnify parts of the screen"
DEPENDS += " libxaw libxt"
PE = "1"

SRC_URI[archive.md5sum] = "32f7ed4c089365cadb9382f6fbd750a9"
SRC_URI[archive.sha256sum] = "0368268a352d302d0b84229a71e3ea0e8d1c44019b1f06b6301ad7a106418553"
