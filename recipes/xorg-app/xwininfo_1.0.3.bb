require xorg-app-common.inc
DESCRIPTION = "window information utility for X"
DEPENDS += " libxmu libxext "
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "721f84332c98c33152460bb22ba9ded6"
SRC_URI[archive.sha256sum] = "fbe3a1aafbc6fa113e58971ff2a82605a7e106af8b810eea4b7512de58a5478a"
