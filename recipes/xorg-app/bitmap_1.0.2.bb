require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11 libxmu xbitmaps libxt"


SRC_URI[archive.md5sum] = "78e8ab5c1830e2cdfbff7a952162a5a7"
SRC_URI[archive.sha256sum] = "83719927ac4309f42e3cadde125a52cfba2e9c951115ac4c017f292f6e4c14bc"
