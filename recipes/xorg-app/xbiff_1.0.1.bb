require xorg-app-common.inc
DEPENDS += " libxaw xbitmaps libxext"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "404f5add4537d22dd109c33e518a5190"
SRC_URI[archive.sha256sum] = "9845b1fa8a1cfd408f01fd69b66808068e847cdc925d114c7723c17934a96503"
