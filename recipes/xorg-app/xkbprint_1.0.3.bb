require xorg-app-common.inc
DEPENDS += " libxkbfile "
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "526b5ba87cccd05aa700fa628bcfda3e"
SRC_URI[archive.sha256sum] = "fa846db8e588018134bd550f80eb129e4ddfdb96f3b157603a57ae2cdf5892c0"
