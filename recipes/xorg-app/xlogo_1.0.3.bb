require xorg-app-common.inc
DEPENDS += " libxaw libxprintutil libxp libxrender libxft libxext libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "8149f95f5a0f04f404549363557eef41"
SRC_URI[archive.sha256sum] = "868ecf47a6c234fc717f513dc938c8293dbe16c970c064b6aa7dc25e61646a0c"
