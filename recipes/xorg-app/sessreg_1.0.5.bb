require xorg-app-common.inc
PE = "1"

DESCRIPTION = "a simple program for managing utmp/wtmp entries"

DEPENDS += " virtual/libx11"


SRC_URI[archive.md5sum] = "00e834c3cbfd990e9d7d5ddc834242df"
SRC_URI[archive.sha256sum] = "3308fbd0018d53bb818fee9de1cde484965b740073d5d240efa4cfc881c9d1a9"
