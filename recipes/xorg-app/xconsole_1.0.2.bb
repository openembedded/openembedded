require xorg-app-common.inc
PE = "1"

DEPENDS += " libxt"


SRC_URI[archive.md5sum] = "8678ddd23573022d68dcd883ae239be8"
SRC_URI[archive.sha256sum] = "45db847e810a932bb962041a4c242f97779142f7e36feec64ec5f9073bd9b377"
