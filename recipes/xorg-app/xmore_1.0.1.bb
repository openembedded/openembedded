require xorg-app-common.inc
PE = "1"

DEPENDS += " libxprintutil libxp libxt"


SRC_URI[archive.md5sum] = "d36e918dce779a9d207b7a266f4e87c8"
SRC_URI[archive.sha256sum] = "653566be73c474bc45f1a6631e14b008445c74557a8f6f46effee1ac3e8f2527"
