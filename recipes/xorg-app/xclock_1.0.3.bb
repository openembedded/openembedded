require xorg-app-common.inc
DESCRIPTION = "analog / digital clock for X"
DEPENDS += " virtual/libx11 libxaw libxrender libxft libxkbfile libxt"
PE = "1"

SRC_URI[archive.md5sum] = "2b1a3d030d87e62a591db8ee4c0072e6"
SRC_URI[archive.sha256sum] = "10b5777ae9ef2a10d4cf447bd1bf13372d7061573835c2c87d5c948b65e9577f"
