require xorg-app-common.inc
DESCRIPTION = "point and click selection of X11 font names"
DEPENDS += " libxaw"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "299fabe7d7be92b6572d814895ce3bb1"
SRC_URI[archive.sha256sum] = "95046ac274b5480ab57c8e04ca04f858957e139b1e8b6ddf5de869bbff7b9ee0"
