require xorg-app-common.inc
PE = "1"

DEPENDS += " libxaw libxprintutil libxp libxrender libxft libxext libxt"


SRC_URI[archive.md5sum] = "4c5482552f38a7d42398a694cc9b2ee6"
SRC_URI[archive.sha256sum] = "de59f9be3d45fe93f445f39bec3cea09753a671e56863ce77e3a797d2df526b2"
