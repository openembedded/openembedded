require xorg-app-common.inc
DESCRIPTION = "a filter for locale and ISO 2022 support on Unicode terminals"
DEPENDS += " zlib zlib virtual/libx11 libfontenc"
PE = "1"

SRC_URI[archive.md5sum] = "fd8579a993c4480978e3504a4c53c189"
SRC_URI[archive.sha256sum] = "8eeb1cf7809acc17cf6cecfdc899613854560052229b21e6115b03a088cd059b"
