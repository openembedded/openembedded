require xorg-app-common.inc

DESCRIPTION = "X server resource database utility"
LICENSE = "xrdb"
DEPENDS += "libxmu"
PE = "1"

SRC_URI[archive.md5sum] = "8dd881cd5a7dcb6e456549817f0fb475"
SRC_URI[archive.sha256sum] = "8d062a3764665fcf22b14df4a5aca6af1e6d7d613296875b31b68e74ef66fc99"
