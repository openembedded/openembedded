require xorg-app-common.inc

DESCRIPTION = "utility for modifying keymaps and pointer button mappings in X"
LICENSE = "MIT"
PE = "1"

SRC_URI[archive.md5sum] = "bbe021f812e0014a8ee3692317788119"
SRC_URI[archive.sha256sum] = "805a63525d99f59d60a11aa89121fb9cdb001c8d542237ac4deafbadc7bd0bed"
