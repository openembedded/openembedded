require xorg-app-common.inc

DESCRIPTION = "Print out X-Video extension adaptor information"
DEPENDS += " libxv"
PE = "1"

SRC_URI[archive.md5sum] = "8cc299b2cb636b5f7fe672610789d3d4"
SRC_URI[archive.sha256sum] = "0a318f6ca0d92bd5cc2ab9d2690f6120b3e1537b7902ce110469864869e86efb"
