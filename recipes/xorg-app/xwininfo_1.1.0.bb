require xorg-app-common.inc
DEPENDS += " libxmu libxext "
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "932cb1393dee3caaf26f3515f640d783"
SRC_URI[archive.sha256sum] = "759e03d80b2a8bc843d501d5fd91fe1506da403019b6f165d32aa1b9909f8cf8"
