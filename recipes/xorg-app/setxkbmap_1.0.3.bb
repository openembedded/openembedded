require xorg-app-common.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS += " libxkbfile virtual/libx11"


SRC_URI[archive.md5sum] = "2b53542095a35a8a5731164118643883"
SRC_URI[archive.sha256sum] = "086f67c8272ceca059c64e127dbdb66ccad8de6f532aee02d22786543718a508"
