require xorg-app-common.inc
DEPENDS += " libxp libxprintutil "
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "c1558277f4a010473ff0744845c49537"
SRC_URI[archive.sha256sum] = "adc60a1808e0974b75a0e7f95022f23411a0e2e9f83e84c441cba5f28f8db072"
