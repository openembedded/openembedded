require xorg-app-common.inc

DESCRIPTION = "xmessage displays a message or query in a window."
DEPENDS += " libxaw libxt"
PE = "1"

SRC_URI[archive.md5sum] = "76ac52710234ebb9d0e2762bb5d11ea1"
SRC_URI[archive.sha256sum] = "cfa35d3ad4ad1306e49878163982e9d54872a20a497e77ab0a8d5de05c8b3d5b"
