require xorg-app-common.inc
PE = "1"

DEPENDS += " libxt libxmu"


SRC_URI[archive.md5sum] = "ba7dbde81be24fc1bd4156b360e5f8cf"
SRC_URI[archive.sha256sum] = "1b8dd25483280fc2a4a7d977b4a43dc4228b9c65e904c3d4ee68245705d4ae35"
