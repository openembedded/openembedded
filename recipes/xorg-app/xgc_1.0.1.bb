require xorg-app-common.inc
DEPENDS += " libxaw libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "72fc8dd68f585000c0a542eba0264571"
SRC_URI[archive.sha256sum] = "7caddfc6c34f62a4ab2dba2ba34085f6b2343b36ec1bec3b522a2188170e1093"
