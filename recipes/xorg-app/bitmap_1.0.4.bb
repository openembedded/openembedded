require xorg-app-common.inc
DEPENDS += " virtual/libx11 libxmu xbitmaps libxt"
PE = "1"

SRC_URI[archive.md5sum] = "7d0c1ac193be2491c72a91ccf37ef18e"
SRC_URI[archive.sha256sum] = "2517aaa015795a348435e4e83bafe7642d4b2fe1976ee982a5d652cf417f79d8"
