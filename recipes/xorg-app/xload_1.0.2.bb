require xorg-app-common.inc

DESCRIPTION = "system load average display for X"
DEPENDS += " libxaw libxt"
PE = "1"

SRC_URI[archive.md5sum] = "b41ed6b4bcfc9897366c27a94d2bf150"
SRC_URI[archive.sha256sum] = "86b176b6efc52557b1c7631bfdd5c17e7060a438e1e85ce15ec9657be356c50b"
