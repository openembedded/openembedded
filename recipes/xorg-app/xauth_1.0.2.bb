require xorg-app-common.inc

DESCRIPTION = "X authority file utility"
DEPENDS += "libxau libxext libxmu"
PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "31b956edaeb453ddaa640420e97b25b2"
SRC_URI[archive.sha256sum] = "569e5a581e5eb16abf1c04a66da22c6dade14578ab34e5e78b8724bb655f1f17"
