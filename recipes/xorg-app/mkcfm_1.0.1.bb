require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11 libxfont libfs libfontenc"


SRC_URI[archive.md5sum] = "d5d560ea77541591d2a6656991286457"
SRC_URI[archive.sha256sum] = "7fbadfa5cb38f7d754214b792854c4a0cb32fd1c9b5ae8ff05434cb3b3acbe01"
