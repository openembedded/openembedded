require xorg-app-common.inc
DESCRIPTION = "print an X window dump"
DEPENDS += " libxmu "
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "83f623f961400ecc56ff52a716308173"
SRC_URI[archive.sha256sum] = "70375ea6b3e17cabc35492f87b5b138295c8f0258d65b0fbba998e3ff69bb634"
