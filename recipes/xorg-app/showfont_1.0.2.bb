require xorg-app-common.inc
PE = "1"

DEPENDS += " libfs"


SRC_URI[archive.md5sum] = "8f83d774ed4cc2a6dca86edd856d820a"
SRC_URI[archive.sha256sum] = "9bd0373659b2f24120dba887fd155f99aed02e4a7c2afae69e7db1c1fa05e88c"
