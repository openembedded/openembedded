require xorg-app-common.inc
DEPENDS += " libxmu "
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "ecd9167fbfdfc3cfef7e0bb089edd25b"
SRC_URI[archive.sha256sum] = "b7a6c889911a0ab52f9f92a83658abb81e213969ad4e6c73c11c9274a438b01e"
