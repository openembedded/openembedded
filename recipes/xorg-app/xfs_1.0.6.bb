require xorg-app-common.inc

DESCRIPTION = "X fontserver"
DEPENDS += " libfs libxfont xtrans"
PE = "1"

SRC_URI[archive.md5sum] = "a62ea490a8b97f74b53732df8fc309d8"
SRC_URI[archive.sha256sum] = "5a3ad18fdc67e261454740217f7c02d1b6825013abcebdcd778a4865fd823353"
