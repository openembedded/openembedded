require xorg-app-common.inc

DESCRIPTION = "X fontserver"
DEPENDS += " libfs libxfont xtrans"
PE = "1"

SRC_URI[archive.md5sum] = "f10717e45535b64eb45226aac571dac2"
SRC_URI[archive.sha256sum] = "34b5040b3db7552fc1cdfa46f926ce5b7217ea5d77cfafbbddf94fbae6b4f482"
