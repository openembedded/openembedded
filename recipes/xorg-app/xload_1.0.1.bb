require xorg-app-common.inc
DEPENDS += " libxaw libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "ba013813f9c21eb015559466f8d02a44"
SRC_URI[archive.sha256sum] = "8d51184d6b18eea2f64e0c5b88cd95edff8353ce6529e780f95b1f2347babbf2"
