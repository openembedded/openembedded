require xorg-app-common.inc
PE = "1"

DESCRIPTION = "converts BDF fonts to PCF fonts"

DEPENDS += " libxfont"

