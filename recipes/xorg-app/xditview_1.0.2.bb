require xorg-app-common.inc
DEPENDS += " libxaw libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "dbf480019b75377154b6976726809bba"
SRC_URI[archive.sha256sum] = "e5d02b60a8f383a20c44cc7d718455075344fb37d171b0397b84f1cc8d49e776"
