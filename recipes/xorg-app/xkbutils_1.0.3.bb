require xorg-app-common.inc
DEPENDS += " libxaw libxkbfile "
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "52ad6d8d87577a8ac736ab5488bec210"
SRC_URI[archive.sha256sum] = "e409af0730788aa94ee22711750792546465a8f4729a0084d31a32c3ef0849bd"
