require xorg-app-common.inc
PE = "1"

DEPENDS += " libxmu libxext virtual/libx11"


SRC_URI[archive.md5sum] = "e2a9bf5ab7f2a0866700a3b49dd8c6bf"
SRC_URI[archive.sha256sum] = "df9a52788632cd3338e7bd7107ac732b11b8e2c367d4600578cd77e350428ee4"
