require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11"


SRC_URI[archive.md5sum] = "6e3c5d0297d88e890b6f5df31f73dd60"
SRC_URI[archive.sha256sum] = "d2de2d39b4479e23adc92d131f66e87db41441aae11b72991bb01d5f6c93336c"
