require xorg-app-common.inc
PE = "1"

DEPENDS += " libxaw libxprintutil libxp libxrender libxft libxext libxt"


SRC_URI[archive.md5sum] = "7365c0852750134119734bc1879f60ca"
SRC_URI[archive.sha256sum] = "47a8aa4e8190772e24dd58266fdd4ba2723b5d7a23365a3e4c07c1263ffb3130"
