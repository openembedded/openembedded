require xorg-app-common.inc
DESCRIPTION = "Sets the visual appearance of the X root window"
LICENSE = "MIT"
DEPENDS += "libxmu xbitmaps"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "b78a2da4cf128775031a5a3422fc0b78"
SRC_URI[archive.sha256sum] = "88f13e949e7aea126239e5c9b3fe7bb7c2ecf70c70774ae41218789d9cfe5fad"
