require xorg-app-common.inc
DEPENDS += " libxmu libxext "
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "7a7f44b826d877ba39c19cf5913978d7"
SRC_URI[archive.sha256sum] = "645a57be4870fb6aba459e7dc96f4d8eaafa3b31bbcd42c997ac4cb021a2343d"
