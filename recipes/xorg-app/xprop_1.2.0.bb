require xorg-app-common.inc
DESCRIPTION = "a property displayer for X"
DEPENDS += " libxmu "
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "e6d0673a1e1e469f0a6220a6868fb94b"
SRC_URI[archive.sha256sum] = "53508c082b03dbbfd68489cb21392023f3e62ca9c921e1fb39b92ad10fbe6b9c"
