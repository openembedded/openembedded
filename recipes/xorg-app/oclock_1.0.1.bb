require xorg-app-common.inc
DEPENDS += " libxmu libxext libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "91f49547f9ed3cd0137c8b7c3183e360"
SRC_URI[archive.sha256sum] = "49ab7d4f6402fbbe30714012ee38b49da17789f3a29ac41917987ce18c74217c"
