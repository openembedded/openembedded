require xorg-app-common.inc
PE = "1"

DEPENDS += " virtual/libx11 libxmu"


SRC_URI[archive.md5sum] = "44473b880d26bfbe8b3d4d72b183cba7"
SRC_URI[archive.sha256sum] = "988c71c6dc3519523fe5844ee3e49d91f843a83c783dd0baa20526d9d2981698"
