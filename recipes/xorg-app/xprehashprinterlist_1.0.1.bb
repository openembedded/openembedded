require xorg-app-common.inc
PE = "1"

DEPENDS += " libxp virtual/libx11"


SRC_URI[archive.md5sum] = "99ee20a9af25375895f5d7ebc1004163"
SRC_URI[archive.sha256sum] = "ba67e9256f703d614ab891b1d676fc26e7479094b957370cbb363c78b2f20259"
