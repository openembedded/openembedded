PR = "${INC_PR}.0"

require quagga.inc

QUAGGASUBDIR = "/attic"
SRC_URI[quagga-0.99.6.md5sum] = "78137ecaa66ff4c3780bd05f60e51cf5"
SRC_URI[quagga-0.99.6.sha256sum] = "a22c927f9ceb7152b0c45c939ccb81217c8d614f3c411c86781b24520f2ec15a"
