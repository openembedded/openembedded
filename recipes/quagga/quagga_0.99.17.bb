require quagga.inc

PR = "${INC_PR}.0"

SRC_URI[quagga-0.99.17.md5sum] = "37b9022adca04b03863d2d79787e643f"
SRC_URI[quagga-0.99.17.sha256sum] = "1d77df121a334e9504b45e489ee7ce35bf478e27d33cd2793a23280b59d9efd4"

QUAGGASUBDIR = ""
