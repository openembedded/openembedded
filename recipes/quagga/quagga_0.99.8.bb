require quagga.inc

PR = "${INC_PR}.0"

QUAGGASUBDIR = "/attic"
SRC_URI[quagga-0.99.8.md5sum] = "0a53fb579033fa57ca0e5c3ff0b52105"
SRC_URI[quagga-0.99.8.sha256sum] = "7e745118921982ad7f67a6733161f74c88ba71c587158ab335f0581124be551d"
