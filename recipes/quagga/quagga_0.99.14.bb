require quagga.inc

QUAGGASUBDIR = ""
