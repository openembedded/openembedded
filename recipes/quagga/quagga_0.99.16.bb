require quagga.inc

PR = "${INC_PR}.0"

SRC_URI[quagga-0.99.16.md5sum] = "350fb150be526cdfc4d2b093cb4d69a7"
SRC_URI[quagga-0.99.16.sha256sum] = "840e376bf42a3c5ee1069eedddb195749b1ebadeef6cacd9fee24ed6f44c35c5"

QUAGGASUBDIR = ""
