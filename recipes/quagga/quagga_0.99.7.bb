require quagga.inc

QUAGGASUBDIR = "/attic"