require sysfsutils.inc

PR = "${INC_PR}"

SRC_URI[md5sum] = "b7857c045ef3b4810c9b8be965c05fb9"
SRC_URI[sha256sum] = "d162ddc4f4a29c770549cb135da179e205480c065739dbe6c3c1bed6d84a3060"
