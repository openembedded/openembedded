require sysfsutils.inc

PR = "${INC_PR}"

includedir .= "/sysfs"

SRC_URI[md5sum] = "d11c99271531be3c1e6d36b53968cd2b"
SRC_URI[sha256sum] = "03e3dc79fd7b36266372de0d331d792c04d185e57495c6fb1d46a0ea0ed0b04d"
