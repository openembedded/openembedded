require radlib-common.inc
require radlib-mysql.inc
PR = "r1"

SRC_URI[md5sum] = "e3a4b94c4c70b66accb018fdd0e93209"
SRC_URI[sha256sum] = "fff54e79937babd9e519f2f56c60e15eee6c453cba9ad2d238154d6fc96450bf"
