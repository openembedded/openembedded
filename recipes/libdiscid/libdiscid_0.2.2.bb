require ${PN}.inc

PR = "r1"

SRC_URI[md5sum] = "ee21ddbe696a3c60e14827a75f3bcf5b"
SRC_URI[sha256sum] = "974b5d5ab23fb45910a4fe171045a22a749cd8cb9833168f7178839993a58402"
