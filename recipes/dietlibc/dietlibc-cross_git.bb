require dietlibc-git.inc
require dietlibc-cross.inc
