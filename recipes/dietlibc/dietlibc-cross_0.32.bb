require dietlibc-${PV}.inc
require dietlibc-cross.inc
