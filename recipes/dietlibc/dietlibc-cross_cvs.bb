require dietlibc-cvs.inc
require dietlibc-cross.inc
