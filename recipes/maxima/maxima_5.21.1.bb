DESCRIPTION = "Free computer algebra environment based on Macsyma"
HOMEPAGE = "http://maxima.sourceforge.net/"
LICENSE = "GPLv2"

SRC_URI = "http://downloads.sourceforge.net/project/maxima/Maxima-source/${PV}-source/${P}.tar.gz"
SRC_URI[md5sum] = "e08ed533f3059cec52788ef35198bdcc"
SRC_URI[sha256sum] = "1dae887e1787871437d699a6b1acc1c1f7428729487492a07c6a31e26bf53a1b"

inherit autotools
