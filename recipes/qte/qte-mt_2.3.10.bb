require qte-common_${PV}.inc
PR = "r29"

EXTRA_OECONF += "-thread"

DEFAULT_PREFERENCE = "1"
