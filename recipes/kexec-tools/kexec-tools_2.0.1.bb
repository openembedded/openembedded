require kexec-tools2.inc
export LDFLAGS = "-L${STAGING_LIBDIR}"
EXTRA_OECONF = " --with-zlib=yes"

PR = "r2"

DEFAULT_PREFERENCE = "1"

SRC_URI[md5sum] = "a7710a89fb0096002bccc57ab202a874"
SRC_URI[sha256sum] = "95f352870df977271d912b6093f034bd3345e47a157493db96d1047b7654564d"
