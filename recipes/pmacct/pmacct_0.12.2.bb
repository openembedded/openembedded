PR = "${INC_PR}.0"
include pmacct.inc

SRC_URI[md5sum] = "1c656ea9ca13455c54e8efb9f8299b3d"
SRC_URI[sha256sum] = "5b4555ae2bc70eff9ad6ffc0a656108edd007bd826fa6df9bd16b98314ca760d"
