require bug-app.inc

DESCRIPTION = "Turns your Bug into a picture frame. Shake it once, then hold it still to take a picture. Shake it again to erase the picture."
HOMEPAGE = "http://buglabs.net/applications/pictureframe"

DEPENDS += "service-tracker com.buglabs.bug.module.motion com.buglabs.bug.module.lcd com.buglabs.bug.module.camera com.buglabs.common com.buglabs.bug.base com.buglabs.osgi "

PV = "2"

SRC_LINK = "http://buglabs.net/program_version/download/142"

APIVERSION = ""
