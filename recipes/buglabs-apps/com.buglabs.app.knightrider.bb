require bug-app.inc

DESCRIPTION = "Blinks base button LEDs in night rider pattern."
HOMEPAGE = "http://buglabs.net/applications/KnightRider"

DEPENDS += "com.buglabs.bug.base com.buglabs.osgi service-tracker com.buglabs.common "

PV = "3"

SRC_LINK = "http://buglabs.net/program_version/download/146"

APIVERSION = ""
