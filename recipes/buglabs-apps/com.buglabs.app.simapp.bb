require bug-app.inc

DESCRIPTION = "The BUGapp for N-Body simulation tutorial."
HOMEPAGE = "http://buglabs.net/applications/SimApp"

DEPENDS += "service-tracker com.buglabs.common com.buglabs.bug.jni.accelerometer com.buglabs.bug.module.motion com.buglabs.bug.module.lcd "

PV = "3"

SRC_LINK = "http://buglabs.net/program_version/download/774"

APIVERSION = ""
