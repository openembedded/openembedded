require bug-app.inc

DESCRIPTION = "Press hotkeys and hear sounds!  "
HOMEPAGE = "http://buglabs.net/applications/Bugboard"

DEPENDS += "com.buglabs.bug.audio.common com.buglabs.bug.module.audio com.buglabs.bug.audio.common com.buglabs.common com.buglabs.osgi.http service-tracker "

PV = "4"

SRC_LINK = "http://buglabs.net/program_version/download/936"

APIVERSION = ""
