require bug-app.inc

DESCRIPTION = "This app shows how to use the 'com.buglabs.common.regexp':http://buglabs.net/applications/com.buglabs.common.regexp library "
HOMEPAGE = "http://buglabs.net/applications/RegExpSample"

DEPENDS += "service-tracker com.buglabs.app.com.buglabs.common.regexp com.buglabs.osgi.cm com.buglabs.common com.buglabs.osgi com.buglabs.bug.module.lcd "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/851"

APIVERSION = ""
