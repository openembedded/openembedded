require bug-app.inc

DESCRIPTION = "EclipseCon Talk"
HOMEPAGE = "http://buglabs.net/applications/EclipseConMotionSensor"

DEPENDS += "com.buglabs.bug.base com.buglabs.osgi com.buglabs.common service-tracker com.buglabs.bug.module.motion "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/132"

APIVERSION = ""
