require bug-app.inc

DESCRIPTION = "A motion alarm clock utility using BUGmotion. To turn the alarm off, you must keep the BUG consistently moving for a few seconds!"
HOMEPAGE = "http://buglabs.net/applications/MotionAlarmClock"

DEPENDS += "com.buglabs.bug.base com.buglabs.bug.menu com.buglabs.bug.module.motion com.buglabs.common com.buglabs.osgi service-tracker "

PV = "2"

SRC_LINK = "http://buglabs.net/program_version/download/779"

APIVERSION = ""
