require bug-app.inc

DESCRIPTION = "The source project that accompanies the BUG tutorial found here:\
http://bugcommunity.com/wiki/index.php/The_Great_Baby_Monitor_BUGapp_Tutorial\
"
HOMEPAGE = "http://buglabs.net/applications/BugBabyMonitor"

DEPENDS += "com.buglabs.bug.module.camera com.buglabs.bug.module.motion service-tracker com.buglabs.common "

PV = "3"

SRC_LINK = "http://buglabs.net/program_version/download/715"

APIVERSION = ""
