require bug-app.inc

DESCRIPTION = "VirtKeyboard"
HOMEPAGE = "http://buglabs.net/applications/VirtKeyboard"

DEPENDS += "com.buglabs.bug.menu com.buglabs.bug.module.lcd com.buglabs.common com.buglabs.osgi service-tracker "

PV = "3"

SRC_LINK = "http://buglabs.net/program_version/download/72"

APIVERSION = ""
