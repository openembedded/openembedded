require bug-app.inc

DESCRIPTION = "\
'ps' in a BUG window.  No terminal typing necessary!"
HOMEPAGE = "http://buglabs.net/applications/BUG_TOP"

DEPENDS += "com.buglabs.common com.buglabs.app.shellservice com.buglabs.bug.module.lcd "

PV = "2"

SRC_LINK = "http://buglabs.net/program_version/download/667"

APIVERSION = ""
