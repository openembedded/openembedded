require bug-app.inc

DESCRIPTION = "Shows lon/lat coordinates on statusbar.  Requires GPS module."
HOMEPAGE = "http://buglabs.net/applications/SimpleLocationViewer"

DEPENDS += "com.buglabs.bug.module.gps com.buglabs.osgi com.buglabs.nmea service-tracker com.buglabs.common "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/559"

APIVERSION = ""
