require bug-app.inc

DESCRIPTION = "Very simple demonstration bundle that can be used with the buttoneventadapter bundle. It will print any events it receives, so install this one and press buttons on your (virtual) bug."
HOMEPAGE = "http://buglabs.net/applications/buttoneventdemo"

DEPENDS += "service-tracker com.buglabs.app.buttoneventadapter com.buglabs.osgi com.buglabs.common "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/136"

APIVERSION = ""
