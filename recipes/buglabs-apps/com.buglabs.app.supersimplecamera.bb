require bug-app.inc

DESCRIPTION = "Take a picture, show it on the screen."
HOMEPAGE = "http://buglabs.net/applications/SuperSimpleCamera"

DEPENDS += "com.buglabs.bug.module.camera com.buglabs.osgi com.buglabs.common service-tracker com.buglabs.bug.module.lcd "

PV = "2"

SRC_LINK = "http://buglabs.net/program_version/download/700"

APIVERSION = ""
