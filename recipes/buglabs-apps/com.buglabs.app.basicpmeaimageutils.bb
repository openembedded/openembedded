require bug-app.inc

DESCRIPTION = "Some simple library code for creating a GIF or BMP from an awt.Image\
If anyone has code for creating a jpeg, png, or whatnot, please let me know and I'll add it to this.\
The GIF code was taken from here: http://www.acme.com/java/software/Acme.JPM.Encoders.GifEncoder.html\
"
HOMEPAGE = "http://buglabs.net/applications/Basic+pMEA+Image+Utils"

PV = "2"

SRC_LINK = "http://buglabs.net/program_version/download/368"

APIVERSION = ""
