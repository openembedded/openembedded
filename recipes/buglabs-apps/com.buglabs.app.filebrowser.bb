require bug-app.inc

DESCRIPTION = "A simple file browser using the LCD touchscreen. \
Currently browses through directories and views text files, and will do much more soon!\
V1.1\
Added gif, png, jpeg image support\
Minor bug fixes"
HOMEPAGE = "http://buglabs.net/applications/FileBrowser"

DEPENDS += "com.buglabs.osgi com.buglabs.common com.buglabs.osgi.shell service-tracker com.buglabs.bug.module.lcd "

PV = "2"

SRC_LINK = "http://buglabs.net/program_version/download/798"

APIVERSION = ""
