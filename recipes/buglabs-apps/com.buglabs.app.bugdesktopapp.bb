require bug-app.inc

DESCRIPTION = "This is an example of how to use IDesktopApp and AppUI."
HOMEPAGE = "http://buglabs.net/applications/BUG_Desktop_app"

DEPENDS += "com.buglabs.bug.module.lcd com.buglabs.common com.buglabs.osgi service-tracker "

PV = "5"

SRC_LINK = "http://buglabs.net/program_version/download/677"

APIVERSION = ""
