require bug-app.inc

DESCRIPTION = "This application demonstrates how to use the upcoming 1.4.1 API for Von Hippel, and how to perform analog-to-digital conversions for channels 0 through 3."
HOMEPAGE = "http://buglabs.net/applications/ADCTester"

DEPENDS += "com.buglabs.osgi com.buglabs.common service-tracker com.buglabs.bug.module.vonhippel "

PV = "2"

SRC_LINK = "http://buglabs.net/program_version/download/680"

APIVERSION = ""
