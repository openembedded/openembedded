require bug-app.inc

DESCRIPTION = "My version of Hello World.  This App combines a LCD GUI with the 'VonHippelBlinker (VonHippelBlinker)':http://www.buglabs.net/applications/VonHippelLEDBlinker."
HOMEPAGE = "http://buglabs.net/applications/HelloApp"

DEPENDS += "com.buglabs.osgi com.buglabs.bug.module.vonhippel com.buglabs.common service-tracker com.buglabs.bug.module.lcd "

PV = "2"

SRC_LINK = "http://buglabs.net/program_version/download/694"

APIVERSION = ""
