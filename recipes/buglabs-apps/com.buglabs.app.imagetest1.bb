require bug-app.inc

DESCRIPTION = "Based on the original ImageTest, this variation works by hotkey 2 instead of a timer.  Also, the code is reduced to only require two classes."
HOMEPAGE = "http://buglabs.net/applications/ImageTest1"

DEPENDS += "com.buglabs.bug.module.camera com.buglabs.osgi com.buglabs.common service-tracker com.buglabs.bug.module.lcd "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/162"

APIVERSION = ""
