require bug-app.inc

DESCRIPTION = "BugSecurityCam"
HOMEPAGE = "http://buglabs.net/applications/BugSecurityCam"

DEPENDS += "com.buglabs.bug.base com.buglabs.bug.menu com.buglabs.bug.module.camera com.buglabs.bug.module.motion com.buglabs.common com.buglabs.osgi com.buglabs.osgi.http com.sun.javax.servlet service-tracker "

PV = "2"

SRC_LINK = "http://buglabs.net/program_version/download/29"

APIVERSION = ""
