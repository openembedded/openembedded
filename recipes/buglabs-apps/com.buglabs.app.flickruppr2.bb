require bug-app.inc

DESCRIPTION = "This app will take a photo and upload it to a flickr account."
HOMEPAGE = "http://buglabs.net/applications/FlickrUppr2"

DEPENDS += "service-tracker com.buglabs.bug.module.motion com.buglabs.bug.module.lcd com.buglabs.bug.module.camera com.buglabs.common com.buglabs.bug.module.gps com.buglabs.osgi "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/455"

APIVERSION = ""

BROKEN = "1"
