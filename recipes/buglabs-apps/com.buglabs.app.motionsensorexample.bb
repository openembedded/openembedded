require bug-app.inc

DESCRIPTION = "A quick example on using a motion sensor module. There is a how to in the wiki that goes along with this app.\
"
HOMEPAGE = "http://buglabs.net/applications/MotionSensorExample"

DEPENDS += "com.buglabs.bug.module.motion com.buglabs.osgi service-tracker com.buglabs.common "

PV = "3"

SRC_LINK = "http://buglabs.net/program_version/download/252"

APIVERSION = ""
