require bug-app.inc

DESCRIPTION = "A 'hello world' for the PublicWSProvider interface. Navigate to http://localhost:8082/service/examplews to see the message when running on your Virtual BUG."
HOMEPAGE = "http://buglabs.net/applications/ExampleWS"

DEPENDS += "com.buglabs.osgi service-tracker com.buglabs.common "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/275"

APIVERSION = ""
