require bug-app.inc

DESCRIPTION = "A camera app that stores images on an X Drive account.  See xdrive.com for more information."
HOMEPAGE = "http://buglabs.net/applications/XDriveCamera"

DEPENDS += "com.buglabs.app.org.eclipse.spaces.xdrive service-tracker com.buglabs.bug.menu com.buglabs.bug.module.camera com.buglabs.common com.buglabs.bug.base com.buglabs.osgi "

PV = "5"

SRC_LINK = "http://buglabs.net/program_version/download/161"

APIVERSION = ""
