require bug-app.inc

DESCRIPTION = "Work in progress!\
A basic dice roller app that will simulate rolling dice of different types.  Requires LCD (BUGview) and motion (BUGmotion) modules."
HOMEPAGE = "http://buglabs.net/applications/RPG+Dice+Roller"

DEPENDS += "com.buglabs.bug.module.motion com.buglabs.osgi com.buglabs.common service-tracker com.buglabs.bug.module.lcd "

PV = "3"

SRC_LINK = "http://buglabs.net/program_version/download/167"

APIVERSION = ""
