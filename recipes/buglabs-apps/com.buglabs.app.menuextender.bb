require bug-app.inc

DESCRIPTION = "This example creates a simple application menu. "
HOMEPAGE = "http://buglabs.net/applications/Menu+Extender"

DEPENDS += "com.buglabs.bug.menu com.buglabs.common com.buglabs.osgi service-tracker "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/2"

APIVERSION = ""
