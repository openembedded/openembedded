require bug-app.inc

DESCRIPTION = "Shows basic functionality of the services offered by GPS module"
HOMEPAGE = "http://buglabs.net/applications/GPSDemo"

DEPENDS += "com.buglabs.bug.module.gps com.buglabs.osgi service-tracker com.buglabs.common "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/292"

APIVERSION = ""
