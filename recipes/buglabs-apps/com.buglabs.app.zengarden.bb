require bug-app.inc

DESCRIPTION = "Create a tiny pixel-art Zen Garden."
HOMEPAGE = "http://buglabs.net/applications/ZenGarden"

DEPENDS += "service-tracker com.buglabs.common com.buglabs.nmea com.buglabs.bug.module.lcd "

PV = "6"

SRC_LINK = "http://buglabs.net/program_version/download/1021"

APIVERSION = ""
