require bug-app.inc

DESCRIPTION = "A library bundle for accessing Xdrive.  Written by Maria Vazquez."
HOMEPAGE = "http://buglabs.net/applications/org.eclipse.spaces.xdrive"

PV = "4"

SRC_LINK = "http://buglabs.net/program_version/download/160"

APIVERSION = ""
