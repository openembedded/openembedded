require bug-app.inc

DESCRIPTION = "A super simple OSGi service provider.  Creates a trivial service implementation and registers it with the service registry."
HOMEPAGE = "http://buglabs.net/applications/ServiceProducer"

PV = "2"

SRC_LINK = "http://buglabs.net/program_version/download/472"

APIVERSION = ""
