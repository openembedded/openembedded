require bug-app.inc

DESCRIPTION = "The Concierge Event Admin service.  Event Admin is in the OSGi R4 specification.  Jan Rellermeyer back-ported it for use with Concierge.  Visit the Concierge website for more information: http://concierge.sourceforge.net."
HOMEPAGE = "http://buglabs.net/applications/Event+Admin"

DEPENDS += "com.buglabs.osgi "

PV = "4"

SRC_LINK = "http://buglabs.net/program_version/download/470"

APIVERSION = ""
