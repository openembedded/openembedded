require bug-app.inc

DESCRIPTION = "This deploys a servlet so that the CameraModuleControl is tweakable from a web interface."
HOMEPAGE = "http://buglabs.net/applications/ICameraModuleControlWS"

DEPENDS += "service-tracker com.buglabs.osgi.http com.buglabs.bug.module.camera com.sun.javax.servlet com.buglabs.common com.buglabs.osgi "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/244"

APIVERSION = ""
