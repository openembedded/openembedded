require bug-app.inc

DESCRIPTION = "\
An application that demonstrates blinking LEDs on modules and the base unit.  Is is designed to create modular, open source holiday cheer."
HOMEPAGE = "http://buglabs.net/applications/XmasTree"

DEPENDS += "com.buglabs.bug.base com.buglabs.osgi service-tracker com.buglabs.common "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/405"

APIVERSION = ""
