require bug-app.inc

DESCRIPTION = "An osgi wrapper for the 'RxTx Serial Library(RxTx)':http://users.frii.com/jarvi/rxtx/index.html for using RxTx in the Virtual BUG.  To use RxTx on the BUG (r1.4.3), you need to put 'com.buglabs.bug.jni.rxtx.jar(com.buglabs.bug.jni.rxtx.ja)':http://bugcommunity.com/downloads/com.buglabs.bug.jni.rxtx.jar on your BUG in /usr/share/java and add the following line to /usr/shar/java/init.xargs: \
-istart com.buglabs.bug.jni.rxtx.jar"
HOMEPAGE = "http://buglabs.net/applications/com.buglabs.emulator.rxtx"

PV = "2"

SRC_LINK = "http://buglabs.net/program_version/download/1163"

APIVERSION = ""
