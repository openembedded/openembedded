require bug-app.inc

DESCRIPTION = "This is just a simple game based on the one played in\
FORT BOYARD"
HOMEPAGE = "http://buglabs.net/applications/SimpleGame"

DEPENDS += "com.buglabs.osgi com.buglabs.common service-tracker com.buglabs.bug.module.lcd "

PV = "6"

SRC_LINK = "http://buglabs.net/program_version/download/674"

APIVERSION = ""
