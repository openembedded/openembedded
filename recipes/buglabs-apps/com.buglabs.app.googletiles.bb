require bug-app.inc

DESCRIPTION = "Uses geographical information to retrieve a google maps tile image when a button is pressed and displays the tile on the LCD module."
HOMEPAGE = "http://buglabs.net/applications/GoogleTiles"

DEPENDS += "service-tracker com.buglabs.bug.module.motion com.buglabs.bug.module.lcd com.buglabs.common com.buglabs.bug.module.gps com.buglabs.osgi "

PV = "3"

SRC_LINK = "http://buglabs.net/program_version/download/39"

APIVERSION = ""
