require bug-app.inc

DESCRIPTION = "An example of how to use a service tracker with a custom property set on the service."
HOMEPAGE = "http://buglabs.net/applications/ComplexSTExample"

DEPENDS += "com.buglabs.common service-tracker "

PV = "4"

SRC_LINK = "http://buglabs.net/program_version/download/1169"

APIVERSION = "1.4.3"
