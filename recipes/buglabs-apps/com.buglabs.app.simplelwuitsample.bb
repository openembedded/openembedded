require bug-app.inc

DESCRIPTION = "h2. Version 1\
This simple demo shows how to  create an UI using 'LWUIT(LWUIT)':https://lwuit.dev.java.net/.  I haven't test it on a physical bug. \
\
h4. Notes:\
This app uses *_lwuimb-snapshot.jar_* provided by Guillaume Legris ('http://evolvis.org/projects/lwuimb/(http://evolvis.org/projects/lwuimb/)':http://evolvis.org/projects/lwuimb/)\
Comments and suggestions are welcome. "
HOMEPAGE = "http://buglabs.net/applications/SimpleLWUITSample"

DEPENDS += "com.buglabs.osgi com.buglabs.common service-tracker com.buglabs.bug.module.lcd "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/605"

APIVERSION = ""

BROKEN = "1"
