require bug-app.inc

DESCRIPTION = "This app shows how to use the 'BugDiscover(BugDiscover)':http://www.buglabs.net/applications/BUGDiscover service. \
"
HOMEPAGE = "http://buglabs.net/applications/BugDiscoverDemo"

DEPENDS += "service-tracker com.buglabs.bug.module.lcd com.buglabs.common com.buglabs.app.bugdiscover "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/1024"

APIVERSION = "1.4.3"
