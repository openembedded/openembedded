require bug-app.inc

DESCRIPTION = "Demonstrates basic use of INMEARawFeed. Currently not available in SDK until next integration build."
HOMEPAGE = "http://buglabs.net/applications/GPSRawFeedExample"

DEPENDS += "com.buglabs.bug.module.gps com.buglabs.osgi service-tracker com.buglabs.common "

PV = "2"

SRC_LINK = "http://buglabs.net/program_version/download/397"

APIVERSION = ""

BROKEN = "1"
