require bug-app.inc

DESCRIPTION = "A super simple app that demonstrates the JNotify API."
HOMEPAGE = "http://buglabs.net/applications/JNotify+Home+Dir+Listener"

DEPENDS += "net.contentobjects.jnotify "

PV = "2"

SRC_LINK = "http://buglabs.net/program_version/download/1036"

APIVERSION = "1.4.3"
