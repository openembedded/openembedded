require bug-app.inc

DESCRIPTION = "Converts latitude and longitude values to nearest zip codes."
HOMEPAGE = "http://buglabs.net/applications/LatLonConverter"

DEPENDS += "com.buglabs.common "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/6"

APIVERSION = ""
