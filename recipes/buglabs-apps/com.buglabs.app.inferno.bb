require bug-app.inc

DESCRIPTION = "A silly program to push the CPU to the limit by looking for primes.  "
HOMEPAGE = "http://buglabs.net/applications/Inferno"

DEPENDS += "com.buglabs.common "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/699"

APIVERSION = ""
