require bug-app.inc

DESCRIPTION = "The simplest possible GUI that illustrates drawing a frame with widgets and layout, and handling events thrown by buttons. This goes along with the wiki page of the same name.\
"
HOMEPAGE = "http://buglabs.net/applications/SimpleGUI"

DEPENDS += "com.buglabs.osgi com.buglabs.common service-tracker com.buglabs.bug.module.lcd "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/107"

APIVERSION = ""
