require bug-app.inc

DESCRIPTION = "This is a version of the popular Concierge for the Bug"
HOMEPAGE = "http://buglabs.net/applications/ConciergeBug"

DEPENDS += "com.buglabs.osgi com.buglabs.common service-tracker com.buglabs.bug.module.lcd "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/553"

APIVERSION = ""
