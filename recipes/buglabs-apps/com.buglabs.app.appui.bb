require bug-app.inc

DESCRIPTION = "A prototype application launcher."
HOMEPAGE = "http://buglabs.net/applications/AppUI"

DEPENDS += "service-tracker com.buglabs.common com.buglabs.osgi.shell com.buglabs.bug.module.lcd "

PV = "12"

SRC_LINK = "http://www.buglabs.net/program_version/download/1236"

APIVERSION = ""
