require bug-app.inc

DESCRIPTION = "Library providing 'SWT(SWT)':http://en.wikipedia.org/wiki/Standard_Widget_Toolkit classes for BUG applications. See the How-To listed above to run the library on the BUG, and check out the many 'examples(examples)':http://www.eclipse.org/swt/snippets/ on the Eclipse project page.\
This is definitely beta level, the library runs well on the BUG but without following the instructions in the How-To it will not work on the host machine. "
HOMEPAGE = "http://buglabs.net/applications/libSWT"

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/873"

APIVERSION = ""
