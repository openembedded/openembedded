require bug-app.inc

DESCRIPTION = "ProvaBUG"
HOMEPAGE = "http://buglabs.net/applications/ProvaBUG"

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/55"

APIVERSION = ""
