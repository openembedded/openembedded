require bug-app.inc

DESCRIPTION = "This bundle demonstrates how to listen to hotkey events and display hotkey codes on the status bar."
HOMEPAGE = "http://buglabs.net/applications/Hotkey+Tester"

DEPENDS += "com.buglabs.osgi service-tracker com.buglabs.common "

PV = "2"

SRC_LINK = "http://buglabs.net/program_version/download/56"

APIVERSION = ""
