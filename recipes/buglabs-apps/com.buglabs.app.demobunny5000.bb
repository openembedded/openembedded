require bug-app.inc

DESCRIPTION = "This app is loaded on a BUG to give demos.  It launched native demo apps from the hotkeys."
HOMEPAGE = "http://buglabs.net/applications/DemoBunny5000"

DEPENDS += "com.buglabs.osgi service-tracker com.buglabs.common "

PV = "4"

SRC_LINK = "http://buglabs.net/program_version/download/118"

APIVERSION = ""
