require bug-app.inc

DESCRIPTION = "A service to send text messages via BUG3G. It expects the proper tty to be /dev/ttyUSB3. It'll work just fine if you don't have any other USB serial devices plugged in."
HOMEPAGE = "http://buglabs.net/applications/SMSServiceProvider"

PV = "2"

SRC_LINK = "http://buglabs.net/program_version/download/1153"

APIVERSION = "1.4.3"
