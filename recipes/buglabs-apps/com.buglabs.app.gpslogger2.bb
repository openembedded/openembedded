require bug-app.inc

DESCRIPTION = "Logs information in /tmp/GPSLog.log when a GPS FIX is obtained."
HOMEPAGE = "http://buglabs.net/applications/GPSLogger2"

DEPENDS += "com.buglabs.bug.module.gps com.buglabs.osgi service-tracker com.buglabs.common "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/126"

APIVERSION = ""
