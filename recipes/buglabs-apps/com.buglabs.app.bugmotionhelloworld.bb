require bug-app.inc

DESCRIPTION = "The default behavior for the BUGmotion module. When motion is detected, it prints to the base's LCD."
HOMEPAGE = "http://buglabs.net/applications/BUGmotionHelloWorld"

DEPENDS += "com.buglabs.bug.module.motion com.buglabs.osgi service-tracker com.buglabs.common "

PV = "1"

SRC_LINK = "http://buglabs.net/program_version/download/297"

APIVERSION = ""
