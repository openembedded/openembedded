require bug-app.inc

DESCRIPTION = "A test application for zoom in, zoom out and shutter buttons provided by camera module"
HOMEPAGE = "http://buglabs.net/applications/CameraButtonsTester"

DEPENDS += "com.buglabs.bug.module.camera com.buglabs.osgi service-tracker com.buglabs.common "

PV = "4"

SRC_LINK = "http://buglabs.net/program_version/download/345"

APIVERSION = ""
