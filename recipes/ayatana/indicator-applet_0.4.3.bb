DESCRIPTION = "A small applet to display information from various applications consistently in the panel."
SECTION = "x11/gnome"
DEPENDS = "gtk+ gnome-panel"

inherit autotools
SRC_URI = "http://launchpad.net/indicator-applet/0.4/0.4.3/+download/indicator-applet-0.4.3.tar.gz"

SRC_URI[md5sum] = "de7b233cd7110c9b5ef65d7eb9f14a12"
SRC_URI[sha256sum] = "e2ade303a300968bc9c0aae0b0891e4893e3266eeef3433c1952c1704cbf4447"
