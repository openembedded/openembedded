inherit autotools
SRC_URI = "http://launchpad.net/ido/trunk/0.1.6/+download/ido-0.1.6.tar.gz"

SRC_URI[md5sum] = "7d3b322f0f62560723c134fde28390d7"
SRC_URI[sha256sum] = "5b7d5e97e9b3d2e101779776a9b6334858a2aa754f353d33fde5dc92f5da5215"
