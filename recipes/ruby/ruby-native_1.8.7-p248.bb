require ruby_${PV}.bb
DEPENDS = ""
inherit native
