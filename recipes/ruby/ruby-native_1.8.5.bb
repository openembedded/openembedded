require ruby.inc
inherit native

PR = "r1"

SRC_URI += " file://gcc44.patch;patch=1 "

