require libmrss.inc

PR = "${INC_PR}.1"

