require libmrss.inc

# this version misses the patch applied to 0.17.2 - needs patch rebase
DEFAULT_PREFERENCE = "-1"

PR = "${INC_PR}.1"

