require oprofile.inc

PR = "${INC_PR}.0"

SRC_URI[tarball.md5sum] = "4e407093ac06200185d5a5e6437d7242"
SRC_URI[tarball.sha256sum] = "3f0dd40a7749fc650d25d79d42ebbff8f3b6db310c36e7c3839696cc09077880"
