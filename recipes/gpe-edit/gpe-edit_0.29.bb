LICENSE = "GPL"
inherit gpe

DEPENDS = "gtk+ libdisplaymigration libgpewidget"
SECTION = "gpe"
DESCRIPTION = "Editor for the GPE Palmtop Environment"


SRC_URI[md5sum] = "108d1739f06678d45d1529301de6a7c8"
SRC_URI[sha256sum] = "ec3805a8d7b1577f30379f8b3bd59f5f1e1786aa574f75aa254a30bc19b6b79e"
