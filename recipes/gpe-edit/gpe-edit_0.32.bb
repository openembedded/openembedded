SECTION = "gpe"
DESCRIPTION = "Editor for the GPE Palmtop Environment"
LICENSE = "GPL"
PR = "r1"

DEPENDS = "gtk+ libgpewidget"

inherit gpe

SRC_URI[md5sum] = "ea6fa0be7c84d69ab45c21c45c5a798b"
SRC_URI[sha256sum] = "40f1753f39199bf88c128f2cd6b25e4ce3bd93c46395e12dd7a8cfa73cdbdc51"
