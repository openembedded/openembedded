LICENSE = "GPL"
inherit gpe

DEPENDS = "gtk+ libgpewidget"
SECTION = "gpe"
DESCRIPTION = "Editor for the GPE Palmtop Environment"


SRC_URI[md5sum] = "68d5642f42a169a26bdf71e3e3f3ce50"
SRC_URI[sha256sum] = "29e0fb191988afa5e7df2cb7ffcdb4650c49bb7ed44f4b1f01fc2644b793dbb0"
