require dosbox.inc

SRC_URI[md5sum] = "629413e41224ae9cdd115fdafd55cbdc"
SRC_URI[sha256sum] = "f4eeee90f076d891034faf1268b6352b8df9cb262b787384ed4386cf6ea4faa7"
