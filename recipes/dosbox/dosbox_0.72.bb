require dosbox.inc

PR = "r1"

SRC_URI += "file://gcc-4.3.patch;patch=1"


SRC_URI[md5sum] = "262939cc28966c1f9b07c2bc472b699f"
SRC_URI[sha256sum] = "1747d7d9f1e5c0635b5d2d3e6648e8dc36316b1bc88b3755bf96b7fde499ac79"
