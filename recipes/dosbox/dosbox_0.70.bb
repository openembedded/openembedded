require dosbox.inc

SRC_URI[md5sum] = "ea0a936e88eb294038e67eeb0d7129c4"
SRC_URI[sha256sum] = "05fdfd561eee33de12d978795b7f12338327c6da1ce65971463b58f2e90b48e4"
