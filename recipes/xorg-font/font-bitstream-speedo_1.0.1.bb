require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "5b1856a24b1b46414950febc63880307"
SRC_URI[archive.sha256sum] = "3d231566856c754f48f568f41c15376730d45d9c3ffd37e1d2476097519f22b8"
