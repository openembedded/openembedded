require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "3eeb3fb44690b477d510bbd8f86cf5aa"
SRC_URI[archive.sha256sum] = "caebf42aec7be7f3bd40e0f232d6f34881b853dc84acfcdf7458358701fbe34a"
