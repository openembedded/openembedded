require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "cb7b57d7800fd9e28ec35d85761ed278"
SRC_URI[archive.sha256sum] = "2b18ce10b367ebafe95a17de799b6db9a24e2337188d124adaf68af05b1fac65"
