require xorg-font-common.inc

DESCRIPTION = "Adobe typeface software"

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "fcf24554c348df3c689b91596d7f9971"
SRC_URI[archive.sha256sum] = "979435105f897a70f8993fa02c8362160b0513366c2ab896965416f96dbb8077"
