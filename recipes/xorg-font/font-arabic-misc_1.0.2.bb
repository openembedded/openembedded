require xorg-font-common.inc

DESCRIPTION = "100dpi, 24 point (approximately) font to minimally support (almost) all \
of the Arabic characters available in Unicode."

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "40f50d360831755002ed3b25cc11d62d"
SRC_URI[archive.sha256sum] = "ed3bae41b435c151e75d385456239aaf4d2d26dd6ef52cdc8314de0336206522"
