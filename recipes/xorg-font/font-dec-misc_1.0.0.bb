require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "284e554db1c64fb7580a06df01444a2b"
SRC_URI[archive.sha256sum] = "83386d1225dab1ebc58e7d197acc4c310ed4e29840abf291b1fa2ffac1b68bb9"
