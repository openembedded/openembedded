require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "53ed9a42388b7ebb689bdfc374f96a22"
SRC_URI[archive.sha256sum] = "761455a297486f3927a85d919b5c948d1d324181d4bea6c95d542504b68a63c1"
