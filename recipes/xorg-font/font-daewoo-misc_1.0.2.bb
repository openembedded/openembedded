require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "7db1b5b2304c49df5f44aeb815e265d6"
SRC_URI[archive.sha256sum] = "9d3f13449afc51d21d3de4f049982a92056c71a98bdc43b6b9dbf615c297b9c9"
