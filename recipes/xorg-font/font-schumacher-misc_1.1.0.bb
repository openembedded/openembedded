require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "86f4b7d8b11a2e6da70884c59b5866a3"
SRC_URI[archive.sha256sum] = "3003915fb53930fee5e6086ee7546ea0857ef0fc2311aaf84ed937b1b4de1b4d"
