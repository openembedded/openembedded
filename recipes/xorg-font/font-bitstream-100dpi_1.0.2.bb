require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "af353d08fa119c3da3b5d01f19d91c59"
SRC_URI[archive.sha256sum] = "416d1968e7eae0848c058afaff351ff66ab95632cabab4eeff0cd050c1955613"
