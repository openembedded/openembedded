require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "6f3fdcf2454bf08128a651914b7948ca"
SRC_URI[archive.sha256sum] = "824231e8dffe15299454e47259f29d98001c9cf8ad3d6b5171399e4d71705e79"
