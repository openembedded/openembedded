require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "c500d809e60b0139bf6b4bce6550372a"
SRC_URI[archive.sha256sum] = "3f5dd55cc266386d453827e358a7984b809513db58a8aabfa8d9b3fc85720edf"
