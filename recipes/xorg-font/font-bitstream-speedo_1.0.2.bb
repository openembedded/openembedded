require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "13f6f107be164cfbf6be40d35ecf0c0f"
SRC_URI[archive.sha256sum] = "0708fe0046947b88c082b55844af8a861741dcdf087f0624bdf23fb773d76763"
