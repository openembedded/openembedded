require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "73e8e5f04943e54b69503dcd90821a5f"
SRC_URI[archive.sha256sum] = "2d49cacf910409dfb0776e02e08acec8926794bf63c2eb82a3a3947cf01310fd"
