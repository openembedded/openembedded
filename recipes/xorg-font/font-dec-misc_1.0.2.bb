require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "46e46e60e7dbf1fd6dc264392799d5d8"
SRC_URI[archive.sha256sum] = "b726d0f7fc8e712480cab0db80d24f7c539342d3ed4f426aa0ec6f48a93e51ee"
