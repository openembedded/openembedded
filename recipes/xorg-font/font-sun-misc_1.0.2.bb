require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "a01cb1b68d01840ad3442bac7b5b2701"
SRC_URI[archive.sha256sum] = "22a3d64ec5625e402de2a66f7888920cfaa175c8de1405db163f0b411b2be3f1"
