require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "ad4a8b9443f32c29a4e7001a50af17c0"
SRC_URI[archive.sha256sum] = "a8c95e7c34b8cc82ae97d7db9d482db4fc4ac4f3451ca8b04df1a1bd8efa2764"
