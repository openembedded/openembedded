require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "92bf4ecb373faac545cef2dcbe40be35"
SRC_URI[archive.sha256sum] = "7c57c29f70db18e543a3eb8f785b6b5d1372b78eee27707dbb10359d8ddb1446"
