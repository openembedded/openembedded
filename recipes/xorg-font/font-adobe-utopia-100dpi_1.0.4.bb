require xorg-font-common.inc

DESCRIPTION = "Adobe typeface software"

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "66fb6de561648a6dce2755621d6aea17"
SRC_URI[archive.sha256sum] = "d16f5e3f227cc6dd07a160a71f443559682dbc35f1c056a5385085aaec4fada5"
