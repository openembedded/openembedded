require xorg-font-common.inc
PE = "1"

#DESCRIPTION = ""

DEPENDS = "mkfontscale-native font-util-native"
RDEPENDS = ""

