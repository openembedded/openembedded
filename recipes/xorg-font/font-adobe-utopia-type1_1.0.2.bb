require xorg-font-common.inc

DESCRIPTION = "Adobe typeface software"

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "ad945b19b2db64dec3a19507848ff63b"
SRC_URI[archive.sha256sum] = "8c5f2752e44af6219c1b4cfc178f9721f6dd573039e973f61029136c2756e233"
