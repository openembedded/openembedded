require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "bd63a27f967f4d98a257f7d677f2cb5b"
SRC_URI[archive.sha256sum] = "e6ce520ab2962eaa4d639538fc44b7f4b5a5abf4f273bd8643fcd05b14adfbe5"
