require xorg-font-common.inc

PR = "${INC_PR}.0"
