require xorg-font-common.inc

DESCRIPTION = "These fonts are designed for the display of Syriac text."
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "ccb212a7badf7aefdc9f9a92af428d32"
SRC_URI[archive.sha256sum] = "c7e12b9926b6053f3567eae548840f0b3d283ce34f842b06309a81c1d98d3924"
