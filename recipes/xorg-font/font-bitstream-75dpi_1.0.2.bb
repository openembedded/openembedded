require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "e51e4ed02a7c09022134ce1f6714b277"
SRC_URI[archive.sha256sum] = "3de2cbe0fdbfb1a752aef761f65ad9d64e6881b79822b7028cecbc5ea87c5ff3"
