require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "948f2e07810b4f31195185921470f68d"
SRC_URI[archive.sha256sum] = "481f4fcbbf7005658b080b3cf342c8c76de752e77f47958b2b383de73266d2e0"
