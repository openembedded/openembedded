require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "66dc4284674242913bd333dfe6c2d175"
SRC_URI[archive.sha256sum] = "9e7908b7d7586fb61615c9a3fa1e29c70ef6f24a393abe89f29969d27af93a2e"
