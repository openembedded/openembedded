require xorg-font-common.inc

DESCRIPTION = "Adobe typeface software"

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "71dffebeeb702d10876555c361fb69cf"
SRC_URI[archive.sha256sum] = "3b3ca4ba5b5b73e13b3662b5be16ea92a244adb3303a3625437ff7d385ba6557"
