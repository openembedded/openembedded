require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "df934bfc0339322cee73ee3c5460a648"
SRC_URI[archive.sha256sum] = "2ac19a2bde71cfd614da4e3e90f9ad992a94a8ebd1ee4fee44f8aad6f01363ba"
