require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "5e0c9895d69d2632e2170114f8283c11"
SRC_URI[archive.sha256sum] = "c6ea0569adad2c577f140328dc3302e729cb1b1ea90cd0025caf380625f8a688"
