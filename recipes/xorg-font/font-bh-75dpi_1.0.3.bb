require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "565494fc3b6ac08010201d79c677a7a7"
SRC_URI[archive.sha256sum] = "3486aa51ac92c646a448fe899c5c3dae0024b1fef724d5100d52640d1cac721c"
