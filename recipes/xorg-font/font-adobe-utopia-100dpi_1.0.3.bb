require xorg-font-common.inc

DESCRIPTION = "Adobe typeface software"

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "de543b3cad2dc0c5a5ef16d88b01acae"
SRC_URI[archive.sha256sum] = "e048d1d37210b85bd008004dc55596bb0abdf67d60a4e8b0d5347f6ebd6c8cac"
