require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "b08eb798739f85158fee74977cf335c2"
SRC_URI[archive.sha256sum] = "f570a7245dad60a42f68aed5f7b94e9166ea9c7f4f3ce892c79b7a8b234a1d8f"
