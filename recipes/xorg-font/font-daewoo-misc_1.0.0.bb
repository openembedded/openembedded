require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "61f9eab48c619af5494d3e384d8d7d79"
SRC_URI[archive.sha256sum] = "f198eac92e343a38b1e23288880bac91c439bdc90c61a79a7cb0718e9a468926"
