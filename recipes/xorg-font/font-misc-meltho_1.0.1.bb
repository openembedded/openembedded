require xorg-font-common.inc

DESCRIPTION = "These fonts are designed for the display of Syriac text."
PE = "1"
PR = "${INC_PR}.0"
