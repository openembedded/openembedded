require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "96109d0890ad2b6b0e948525ebb0aba8"
SRC_URI[archive.sha256sum] = "e40fe3e3323c62b738550795457ad555c70c008aa91b5912dfd46f8e745f5e60"
