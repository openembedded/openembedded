require xorg-font-common.inc

DESCRIPTION = "These fonts are designed for the display of Syriac text."
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "e3e7b0fda650adc7eb6964ff3c486b1c"
SRC_URI[archive.sha256sum] = "3721323f13855cf7ca609115a1f7b182491e9b2b9c6e01eb1a2c7f8edd480791"
