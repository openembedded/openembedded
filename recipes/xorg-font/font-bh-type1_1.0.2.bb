require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "da9932f1c325095b48d73f954bdbce62"
SRC_URI[archive.sha256sum] = "ff33bf9d8d3943b45ca7405586350ef9496de4add736d3ee057aa645fad90fe6"
