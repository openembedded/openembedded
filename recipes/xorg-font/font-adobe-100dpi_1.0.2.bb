require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "1518e417b18e22673a8f4e2e4adda47b"
SRC_URI[archive.sha256sum] = "71016e092043bc124f196d5be3d1921ab9131f2597ec15736a289973ca316775"
