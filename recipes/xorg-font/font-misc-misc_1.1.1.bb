require xorg-font-common.inc

SRC_URI[archive.md5sum] = "6e25a0ff5ce776a1b894a7ea117b2858"
SRC_URI[archive.sha256sum] = "c4f09a5c76549b1794bdc7e6be28e5aeb1178681ea76bceccdb11e43494d89ce"
