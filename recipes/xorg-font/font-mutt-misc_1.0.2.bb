require xorg-font-common.inc

DESCRIPTION = "Provides a 12pt, 100dpi proportional font with many of \
the glyphs needed for Unicode text."

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "8296972a99f96600d435d157fccc1501"
SRC_URI[archive.sha256sum] = "6fc514969b44dc23392d2d1deb6de92c10357ef8d0498a182576467cf5032dc4"
