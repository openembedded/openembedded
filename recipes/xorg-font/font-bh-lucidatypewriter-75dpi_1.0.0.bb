require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "fdd9be5b9db94ef363a33e39b7977e2b"
SRC_URI[archive.sha256sum] = "50f2f36f533a49c65842568052fe4d065354ff6f39ab36dd2129f465741da046"
