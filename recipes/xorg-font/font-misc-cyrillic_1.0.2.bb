require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "d6eede978912b85ad96ca409f6a20690"
SRC_URI[archive.sha256sum] = "7821db4a1c9f94540e31dd1003bcac3f694b0de917b2d68bd8140129e64c0498"
