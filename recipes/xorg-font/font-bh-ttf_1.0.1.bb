require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "664df71cb510b744b4a10e778445c37b"
SRC_URI[archive.sha256sum] = "1ce72f84a6c4df7f0e949f915346026ebfeaa5b2e47f7bbc29117ebbf3a7a7c8"
