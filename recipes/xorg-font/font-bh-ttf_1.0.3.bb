require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "e8ca58ea0d3726b94fe9f2c17344be60"
SRC_URI[archive.sha256sum] = "1b4bea63271b4db0726b5b52c97994c3313b6023510349226908090501abd25f"
