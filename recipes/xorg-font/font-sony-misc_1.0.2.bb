require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "5efb8d23f57124c0f65d7112e2fa6997"
SRC_URI[archive.sha256sum] = "6ecb69b1b6ae716158e167217f6179d1b0c138c124e90dfaf2888e3b888fc754"
