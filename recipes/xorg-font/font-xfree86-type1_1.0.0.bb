require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "e66f36a6d68203cc4cf7b56ebbb192dd"
SRC_URI[archive.sha256sum] = "ef76d3b91d1bdaa9ff73cc1e5905ad4bbdc028f06157d0d2319d38e7b7f84a4d"
