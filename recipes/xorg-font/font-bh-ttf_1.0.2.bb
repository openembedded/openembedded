require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "56e740e42bd47676f16f90871a414900"
SRC_URI[archive.sha256sum] = "ac303ed4c5b1d91195978af70bbf6cfeafa1748a3b6ec3197638b5a5bc21011b"
