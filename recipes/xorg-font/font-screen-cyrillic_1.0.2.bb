require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "c912a976b66073acd80c9d5c624f3aae"
SRC_URI[archive.sha256sum] = "c5dd881fb13ff16d358acb27f99f6c281415d3824beb342f3a02603f0efebe11"
