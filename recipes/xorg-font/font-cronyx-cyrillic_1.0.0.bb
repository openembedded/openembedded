require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "22b451e7230b8c003cfc496ee2d360cc"
SRC_URI[archive.sha256sum] = "06c94e7033f5cae77b9ba27b84af7c1d3e7f73a7239346aabf98eda6c7f484ee"
