require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "46588b22678e440741d6220bc3945cbf"
SRC_URI[archive.sha256sum] = "5a8a5513f2c829d56043a0f74980efc11b4b4522f21116f16711998f72c3645b"
