require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

DEPENDS = "mkfontscale-native font-util-native font-util"

SRC_URI[archive.md5sum] = "0f2d6546d514c5cc4ecf78a60657a5c1"
SRC_URI[archive.sha256sum] = "ced6312988a45d23812c2ac708b4595f63fd7a49c4dcd9f66bdcd50d1057d539"
