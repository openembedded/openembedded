require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "98fa04be8f2ad27a0c4d73a06acbcfbc"
SRC_URI[archive.sha256sum] = "f8c0ab277f4a6fd8a68f90bb702de1f2ba25333013c123b6f7dc3bcbc6471caa"
