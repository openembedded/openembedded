require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "6306c808f7d7e7d660dfb3859f9091d2"
SRC_URI[archive.sha256sum] = "53cb1fd83afdbe7939c0eac34003676ee0e6023216892d98054db90b703c98a5"
