require xorg-font-common.inc

DESCRIPTION = "100dpi, 24 point (approximately) font to minimally support (almost) all \
of the Arabic characters available in Unicode."

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "cc0726e4a277d6ed93b8e09c1f195470"
SRC_URI[archive.sha256sum] = "505d9b12a7093389e67a925dfda6346bde26d114c67f0cdca7aeda6e5d3344f4"
