require xorg-font-common.inc

DESCRIPTION = "Adobe typeface software"

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "d086727a7d07b5ed60ca98c6ed88ccd5"
SRC_URI[archive.sha256sum] = "50fa467293cdf2fd909f4a6e32de9da7435dde22e1e6c1066a408e5ac20610f9"
