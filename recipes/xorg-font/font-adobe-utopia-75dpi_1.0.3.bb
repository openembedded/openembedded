require xorg-font-common.inc

DESCRIPTION = "Adobe typeface software"

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "0d694a5591e89d2315d841f414668344"
SRC_URI[archive.sha256sum] = "274dbe4adbb57a35a57c0eb248e01dcdbcd4e4aa0a3834263e4026becd9542e3"
