require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "02eca731d77307c4cb37738a32f2db9f"
SRC_URI[archive.sha256sum] = "f0dc69141e04573aaf27232e72cb312b3b6c7bbadbb562522dde67993ce76535"
