require xorg-font-common.inc

DESCRIPTION = "Adobe typeface software"

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "1c3a2c26bd3f6e406fbadc7380efa369"
SRC_URI[archive.sha256sum] = "dd8c3f5509589f9232b26273fecde2694bd2bb069c6aaa8f504ad3d24775955e"
