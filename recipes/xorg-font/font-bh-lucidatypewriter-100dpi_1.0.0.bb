require xorg-font-common.inc

PE = "1"
