require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "6bb4ce98da5aadae91101484b1de9ea8"
SRC_URI[archive.sha256sum] = "730ca783fb487fbc31885023fb2641420367202215c43fa79739d1f25cc75392"
