require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "173352ddec3d26e2b91df1edcf1ae85b"
SRC_URI[archive.sha256sum] = "0c705a74d7b52e41a1f1aa6732f0200877ba2d4303b79513a524e7cc1b30e2d2"
