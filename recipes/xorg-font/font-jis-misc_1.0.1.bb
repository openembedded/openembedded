require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "5835c99d056f4a29d7d6a5ae873cf00e"
SRC_URI[archive.sha256sum] = "a63b98c204395b61949214db199c38094489336731d4a4179eb053a5bb54e8cf"
