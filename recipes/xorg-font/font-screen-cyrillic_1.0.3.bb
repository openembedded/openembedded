require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "d50d209c9e7580aaba544d54b5e51e76"
SRC_URI[archive.sha256sum] = "4e1a3892cb0059e24acf3156f59122e4fdf14164c3a7ed5d93e0788ef8b7ef0a"
