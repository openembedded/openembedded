require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "e805feb7c4f20e6bfb1118d19d972219"
SRC_URI[archive.sha256sum] = "e444028656e0767e2eddc6d9aca462b16a2be75a47244dbc199b2c44eca87e5a"
