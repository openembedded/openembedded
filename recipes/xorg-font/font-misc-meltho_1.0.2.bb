require xorg-font-common.inc

DESCRIPTION = "These fonts are designed for the display of Syriac text."
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "b6d53e8bcc06e25f868130a0c4619ab2"
SRC_URI[archive.sha256sum] = "ec8813f32d1bfceed96cc186c02be7156bf076954e2e30ac7d41e02ba070b91e"
