require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "813b5d3723c84388a938ab6732e1329c"
SRC_URI[archive.sha256sum] = "d62745bee0f5e4f355f237020667d783ae9fea5f18a864d748ae1287bd176339"
