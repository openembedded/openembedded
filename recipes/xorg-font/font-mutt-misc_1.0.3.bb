require xorg-font-common.inc

DESCRIPTION = "Provides a 12pt, 100dpi proportional font with many of \
the glyphs needed for Unicode text."

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "56b0296e8862fc1df5cdbb4efe604e86"
SRC_URI[archive.sha256sum] = "bd5f7adb34367c197773a9801df5bce7b019664941900b2a31fbfe1ff2830f8f"
