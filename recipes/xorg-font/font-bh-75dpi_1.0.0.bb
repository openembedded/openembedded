require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "6e51cd02f4ce32e1393e34ab17a9b211"
SRC_URI[archive.sha256sum] = "c79467b440cc9389c75d55fba64d0126d0f2e1e6c019dfafb7d89d07802c05bf"
