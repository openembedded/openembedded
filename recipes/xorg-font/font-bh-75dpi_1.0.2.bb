require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "a2c4bd73637330391fd3d16e58be5528"
SRC_URI[archive.sha256sum] = "40fe8a5be3925d6fb2da29b7f0d33bd27858c79b94f3ee38ebc0d86a3d4fa80d"
