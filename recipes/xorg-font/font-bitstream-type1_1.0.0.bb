require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "6610475e2e231242f8f2122a709c3695"
SRC_URI[archive.sha256sum] = "4fce492dcf168837342ea1787ac35b53e4d30361239cba207c9520c42454d903"
