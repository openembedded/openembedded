inherit native
require xorg-font-common.inc

XORG_PN = "font-util"

DEPENDS = "bdftopcf-native"

PE = "1"
