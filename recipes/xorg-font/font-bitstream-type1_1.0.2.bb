require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "27c55f6a938e7153c59fb551b2f491f9"
SRC_URI[archive.sha256sum] = "5deb7a36cd70f8048d0c20a743dd56de9d1ced2e9a3f556678def492b0a54cf1"
