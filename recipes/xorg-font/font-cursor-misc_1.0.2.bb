require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "b0ff8cb54d245d328ba5b9ed38d734ed"
SRC_URI[archive.sha256sum] = "117a000109d0d9b71f1efe5809dac2bc7c254ff9a7a8995f7a295842881e300f"
