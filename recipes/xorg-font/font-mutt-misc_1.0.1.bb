require xorg-font-common.inc

DESCRIPTION = "Provides a 12pt, 100dpi proportional font with many of \
the glyphs needed for Unicode text."

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "aab7ac62b960e77aa11d032bafe1d460"
SRC_URI[archive.sha256sum] = "77bf33cbf5d1849bef4e516698eb45b7d16263a84dcc2299fd61383501906e25"
