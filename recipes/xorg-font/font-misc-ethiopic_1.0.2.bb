require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "bf9879739a9f06dc1980cf16defaa4d9"
SRC_URI[archive.sha256sum] = "250424b04bba8c85bf5ee5af184b6c8c02227360828258acdb2de4f4d71322ce"
