require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "6e7c5108f1b16d7a1c7b2c9760edd6e5"
SRC_URI[archive.sha256sum] = "e19ddf8b5f8de914d81675358fdfe37762e9ce524887cc983adef34f2850ff7b"
