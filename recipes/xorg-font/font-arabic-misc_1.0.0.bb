require xorg-font-common.inc

DESCRIPTION = "100dpi, 24 point (approximately) font to minimally support (almost) all \
of the Arabic characters available in Unicode."

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "81595016e2ff859716fc256ebb136ba6"
SRC_URI[archive.sha256sum] = "90e9dfa3f33805ea2ffe06faa7258d8335cdf415826f963a1d0a76bd8df7bc94"
