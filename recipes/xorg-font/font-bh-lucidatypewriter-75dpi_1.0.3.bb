require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "f6d65758ac9eb576ae49ab24c5e9019a"
SRC_URI[archive.sha256sum] = "4ac16afbe205480cc5572e2977ea63488c543d05be0ea8e5a94c845a6eebcb31"
