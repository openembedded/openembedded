require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "a47681c97bd012196691c95e34d400f1"
SRC_URI[archive.sha256sum] = "4de51765d26b70728a8b6573be89d731be0384466290dbbb216cb05becdf9f71"
