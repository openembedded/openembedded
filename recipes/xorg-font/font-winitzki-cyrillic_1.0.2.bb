require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "2d92227f14910732dc46303d6f8a9543"
SRC_URI[archive.sha256sum] = "f4fbf0ae12b7a0e5dd440cb2d63eb24feada3d283b9e0d588295f799e772ffe0"
