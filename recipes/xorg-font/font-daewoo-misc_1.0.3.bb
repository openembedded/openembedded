require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "0571bf77f8fab465a5454569d9989506"
SRC_URI[archive.sha256sum] = "bc65de70bee12698caa95b523d3b652c056347e17b68cc8b5d6bbdff235c4be8"
