require xorg-font-common.inc

PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "c88eb44b3b903d79fb44b860a213e623"
SRC_URI[archive.sha256sum] = "b8e77940e4e1769dc47ef1805918d8c9be37c708735832a07204258bacc11794"
