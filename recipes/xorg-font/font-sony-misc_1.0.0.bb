require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "0dfddd1a946e4497f009094c0ae1bdd5"
SRC_URI[archive.sha256sum] = "1ae93ae76020b57cb0054ba9f33b4d5aec71342c6596750c07303d5c53452e23"
