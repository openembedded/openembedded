require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_rsync.tar.bz2;name=split_rsync"
SRC_URI[split_rsync.md5sum] = "bf58d29c4f3aba2775d3c4fd6bbbb6b4"
SRC_URI[split_rsync.sha256sum] = "a2322fd558fcd73361ba56be07861b8bca52e7609bdb62b8e87db488b6059f9a"
