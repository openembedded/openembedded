require ${PN}.inc

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_rsync.tar.bz2"
