require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "d5d7c69837cc7dcbf2aa181ff423ab20"
SRC_URI[archive.sha256sum] = "a938c07ea331359f379802c50c33aa0307b913f742ad74087d45e7fb2a1f4d50"
