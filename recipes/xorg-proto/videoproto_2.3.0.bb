require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "fb762146a18207a1e8bc9f299dfc7ac0"
SRC_URI[archive.sha256sum] = "4f2bc94e5a1b60d6f35a9a2589ca98949e8841997f6a9acf4e85f46c1f34045f"
