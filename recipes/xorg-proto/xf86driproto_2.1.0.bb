require xorg-proto-common.inc

PE = "1"

SRC_URI[archive.md5sum] = "309d552732666c3333d7dc63e80d042f"
SRC_URI[archive.sha256sum] = "d23f12deffd03e582e897ed6a7df3ea7f66ee8577f0f61374dcdf2ebffdce1be"
