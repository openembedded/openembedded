DESCRIPTION = "DRI2 extension headers"

require xorg-proto-common.inc

SRC_URI[archive.md5sum] = "3ca8ddb42cd4ee31b8690031303221af"
SRC_URI[archive.sha256sum] = "f352950ffee4437d9da3e216d9a348ba0c7cf80c8c0fb30385c77ce3b780b2a1"
