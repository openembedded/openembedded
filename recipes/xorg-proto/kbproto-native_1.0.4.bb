require kbproto_${PV}.bb
require xorg-proto-native.inc

PR = "r1"

XORG_PN = "kbproto"
