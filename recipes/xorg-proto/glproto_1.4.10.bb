require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "c9f8cebfba72bfab674bc0170551fb8d"
SRC_URI[archive.sha256sum] = "7fb83a28ae24d4f56eca88bc48f0fe414faee1afb2574bfb6257b52e8c716fcf"
