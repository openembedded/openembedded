require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "597491c0d8055e2a66f11350c4985775"
SRC_URI[archive.sha256sum] = "d90d00612cc49292bd8d9dc19efb1c9187385fbe87590d7279a02e5e1066dc71"


CONFLICTS = "randrext"
