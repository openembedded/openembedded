require xorg-proto-common.inc
DESCRIPTION = "DRI2 extension headers"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "1d70f0653b0b3a837853262dc5d34da4"
SRC_URI[archive.sha256sum] = "69def6d1f64b3699ec9c729596d8b096623a62bdda6bbea78ed690421d174c11"
