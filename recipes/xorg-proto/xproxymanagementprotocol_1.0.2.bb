require xorg-proto-common.inc

PROVIDES="xproxymngproto"
PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "d28007a50976204960fc1fc07b4ca093"
SRC_URI[archive.sha256sum] = "c45176d002c85c142ac52774680f5325d330c5ecc32d4d6a056d85ee039a0cbc"
