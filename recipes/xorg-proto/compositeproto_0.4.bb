require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "6281344d656d4e0c8e9db4918efe3d1d"
SRC_URI[archive.sha256sum] = "6013d1ca63b2b7540f6f99977090812b899852acfbd9df123b5ebaa911e30003"

CONFLICTS = "compositeext"
