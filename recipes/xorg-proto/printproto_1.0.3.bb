require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "0f4e7982c6d4ec3b2cf38502dd1293a3"
SRC_URI[archive.sha256sum] = "8b375f8cda83dfc7d84be44af41eedd484d0e2499acbd19bdca5b4056dec7235"
