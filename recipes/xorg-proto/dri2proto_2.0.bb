DESCRIPTION = "DRI2 extension headers"

require xorg-proto-common.inc

SRC_URI[archive.md5sum] = "26f6515322ec50691584ac74291b4254"
SRC_URI[archive.sha256sum] = "1954a7e96d7fe70611c483836ed143e84a069eed6d3dab22c05a531bfb6da9e4"
