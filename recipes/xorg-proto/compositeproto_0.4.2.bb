require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "98482f65ba1e74a08bf5b056a4031ef0"
SRC_URI[archive.sha256sum] = "049359f0be0b2b984a8149c966dd04e8c58e6eade2a4a309cf1126635ccd0cfc"

CONFLICTS = "compositeext"
