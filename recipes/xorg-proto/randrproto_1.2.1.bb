require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "e2e45564f8ce22e00e1360e79c8ccdeb"
SRC_URI[archive.sha256sum] = "102fd42f8f2562450f4e45c28bfb0390c2d30ffa6a805eead15d67018930f654"


CONFLICTS = "randrext"
