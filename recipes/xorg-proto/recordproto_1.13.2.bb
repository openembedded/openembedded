require xorg-proto-common.inc

CONFLICTS = "recordext"
PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "0ed4706564a34fc2aff724aa16d3ff00"
SRC_URI[archive.sha256sum] = "04e77a8b14f373a1825bbe0116cd0db8b2c5dee17b34ba9bddd27e576609cff9"
