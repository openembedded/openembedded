require renderproto_${PV}.bb

PR = "r1"

XORG_PN = "renderproto"

inherit native

SRC_URI[archive.md5sum] = "b160a9733fe91b666e74fca284333148"
SRC_URI[archive.sha256sum] = "c4d1d6d9b0b6ed9a328a94890c171d534f62708f0982d071ccd443322bedffc2"
