require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "ed5416cf7e2ba6e66641c88f12768c0c"
SRC_URI[archive.sha256sum] = "780d249696bb2de7acabded90a465a62cd6cbda3b7f0ccff6ebfdf0d8180f151"
