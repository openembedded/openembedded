require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "acae8edeb05a406f7f60bcbb218a8f1d"
SRC_URI[archive.sha256sum] = "aaab4cbf19c73ded4785ba69cdd7ae23aaf103c7040559283f85fc1237dad6e6"
