DESCRIPTION = "DRI2 extension headers"

require xorg-proto-common.inc

SRC_URI[archive.md5sum] = "3407b494d5e90d584c9af52aa8f9f028"
SRC_URI[archive.sha256sum] = "b2141892a0db35feffa5e952ff5e1d2727c4436b07d7e2e9dd2ed89c8bb3e677"
