require xorg-proto-common.inc

PROVIDES="xproxymngproto"
PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "9de22ca1522008c28fb03dfc41ba2d30"
SRC_URI[archive.sha256sum] = "7382acd8c76fa577beb622cab86cc07fafdcecbbd9b4f209bfa72976c4fd26c2"
