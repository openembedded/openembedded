require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "33ee591e0b1ca5ad7902934541db7d24"
SRC_URI[archive.sha256sum] = "9d2684fac835e9cdf78befff2a58292f54db90094acbfb9f2ed5316fa30d641d"

CONFLICTS = "damageext"
