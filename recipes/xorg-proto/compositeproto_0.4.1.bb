require xorg-proto-common.inc

CONFLICTS = "compositeext"
PE = "1"

XORG_PN = "compositeproto"

SRC_URI[archive.md5sum] = "3692f3f8b2ea10dff3d2cede8dc65e79"
SRC_URI[archive.sha256sum] = "e2744576731e1416503aade0d58a7861d0260f70b993351473a9f38ced606984"
