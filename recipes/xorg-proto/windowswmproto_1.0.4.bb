require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "e74b2ff3172a6117f2a62b655ef99064"
SRC_URI[archive.sha256sum] = "c05bb0edb627554fe97aa1516aed44accf6566b1db0e50332689a24afcebd26b"
