require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "b6a96ffdae084e27487a58314008b000"
SRC_URI[archive.sha256sum] = "07d9b237541f2d6313b5b28f5335d987a766b36c87b133f77cc48f31d969a3ae"
