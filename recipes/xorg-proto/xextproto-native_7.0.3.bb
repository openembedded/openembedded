require xextproto_${PV}.bb
require xorg-proto-native.inc

PR = "r1"

XORG_PN = "xextproto"

SRC_URI[archive.md5sum] = "3a2e0252e853ab30b3bff05ac92ec61c"
SRC_URI[archive.sha256sum] = "3972428e3651c9159aff655c9c794728520c3ce3d66ac219ec5243d5d73d4db4"
