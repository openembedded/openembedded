require xextproto_${PV}.bb

PR = "r1"

XORG_PN = "xextproto"

inherit native

DEPENDS += "util-macros-native"
