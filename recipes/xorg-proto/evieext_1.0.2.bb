require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "2507b5d0f4b2848147fbddd155aa6cfe"
SRC_URI[archive.sha256sum] = "0b85113a9770083715927f9c7a7d0ab354c8a508a91cb6e8e11130851494d125"
