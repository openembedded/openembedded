require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.1"

SRC_URI += "file://7196c9441af941be74180f8e8d4e10a08659b80f.patch"

SRC_URI[archive.md5sum] = "9542f2d36751a8ad7eae9d8e176f70d4"
SRC_URI[archive.sha256sum] = "fc0a94d4df003cb6b6953173e6498d9c4c3268ee24bcc46a1172a1e1dbd3d742"
