require xorg-proto-common.inc

CONFLICTS = "recordext"
PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "70f5998c673aa510e2acd6d8fb3799de"
SRC_URI[archive.sha256sum] = "1bd2375bd2bdaa3ea90aa0a70cf1657a2d61877b6eb7e3fe3e6f1d289e69d067"
