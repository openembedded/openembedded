require xorg-proto-common.inc

CONFLICTS = "renderext"
PR = "r1"
PE = "1"

XORG_PN = "renderproto"

SRC_URI[archive.md5sum] = "28fbe8a59ebd31f098b90ec64f3d133a"
SRC_URI[archive.sha256sum] = "7754dfbbb1e3818f28720fa9647b8a593e9d54626a7896771c2bfac7f75e2726"
