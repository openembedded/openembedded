require xproto_${PV}.bb
require xorg-proto-native.inc
