require xorg-proto-common.inc
DESCRIPTION = "X11 core wire protocol and auxiliary headers"
PE = "1"
