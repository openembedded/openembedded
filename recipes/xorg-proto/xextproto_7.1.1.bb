require xorg-proto-common.inc

PE = "1"

SRC_URI[archive.md5sum] = "fb6ccaae76db7a35e49b12aea60ca6ff"
SRC_URI[archive.sha256sum] = "6d0abd31ddd57c2cb24cecf5fd90b4c29a276e20e3e03ca3c2c57d074f964d99"
