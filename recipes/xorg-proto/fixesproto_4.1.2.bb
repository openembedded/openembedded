require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "bdb58ecc313b509247036d5c11fa99df"
SRC_URI[archive.sha256sum] = "de4cbfccb533c190073445eb2a891d997e89f6fb58204f68ae82871de044f857"


CONFLICTS = "fixesext"
