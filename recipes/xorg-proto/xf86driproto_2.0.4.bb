require xorg-proto-common.inc

PE = "1"

SRC_URI[archive.md5sum] = "01470d088da3a8a3deefa8e1f45d69cb"
SRC_URI[archive.sha256sum] = "f57da66bec8563502fe95c0e3f6ed297d9985862f5b64a5c9d3039719ac7f9da"
