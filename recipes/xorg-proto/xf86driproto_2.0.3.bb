require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "e4a282cfd708b8892fca4425fee9cd7b"
SRC_URI[archive.sha256sum] = "111c469a24374803b08104c725d8318760b226cedccd12b199c83d1b2756b8d6"
