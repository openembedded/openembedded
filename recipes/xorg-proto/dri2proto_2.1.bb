DESCRIPTION = "DRI2 extension headers"

require xorg-proto-common.inc

SRC_URI[archive.md5sum] = "5cb7987d29db068153bdc8f23c767c43"
SRC_URI[archive.sha256sum] = "2b33f7c7658fb8f004c3aaf2717711262baeb5d77cf3fd24e9b6cc263895122d"
