require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "1cc292c562962ad0ad3a253cae68c632"
SRC_URI[archive.sha256sum] = "e8a62b1cafbcfc3b9fed147612ed4320233d0c9d6de30c991c2cd0c691c40910"
