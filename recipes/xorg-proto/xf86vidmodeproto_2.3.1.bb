require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "e793ecefeaecfeabd1aed6a01095174e"
SRC_URI[archive.sha256sum] = "45d9499aa7b73203fd6b3505b0259624afed5c16b941bd04fcf123e5de698770"

CONFLICTS = "xxf86vmext"
