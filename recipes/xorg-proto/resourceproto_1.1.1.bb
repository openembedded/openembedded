require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "8ff0525ae7502b48597b78d00bc22284"
SRC_URI[archive.sha256sum] = "8579818e99aa881c00c04eb5f96fcbeec463816ca8e3cda9d3d25562f7a4b8c6"

CONFLICTS = "resourceext"
