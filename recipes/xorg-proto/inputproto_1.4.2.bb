require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "e2c4cf4c2ad59d1e27f09381f6b4a3c3"
SRC_URI[archive.sha256sum] = "62ba68a056daa89f5b21a02b27f6a4c858933e1c5547c9d16985d9ed182014e6"
