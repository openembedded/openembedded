require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "434b931b02bd83ed9fc44951df81cdac"
SRC_URI[archive.sha256sum] = "a50250770a2eead9d6fd56577e3328d0a6a1c4d425b58faa0f5ca7683169ee8f"

CONFLICTS = "damageext"
