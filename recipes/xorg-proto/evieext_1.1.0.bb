require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "5c74f61d6f77b2e6a083b2b31000be42"
SRC_URI[archive.sha256sum] = "47881a52a8d9da1e41e4f028ed32a8b44f738afbead819c0a07253fdc1641885"
