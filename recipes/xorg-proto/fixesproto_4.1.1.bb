require xorg-proto-common.inc

CONFLICTS = "fixesext"
PR = "r1"
PE = "1"

XORG_PN = "fixesproto"

SRC_URI[archive.md5sum] = "4c1cb4f2ed9f34de59f2f04783ca9483"
SRC_URI[archive.sha256sum] = "e72a32916ad4bbd03847f8945c55582bdbafc039d286ded7365d402a7ff164ef"
