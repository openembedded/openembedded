require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "60df6b625074a9790e28543dcea71651"
SRC_URI[archive.sha256sum] = "48063ed49b200927376645f9ffe65faa39af84d59ba6f60f2abb2f9c6fa3d9f9"
