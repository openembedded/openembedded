require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "42fdcebc66efac02ab4beec2b1b0ad6e"
SRC_URI[archive.sha256sum] = "5ac4d4a308b032727c61fd56db5a2eaadaedfbce5bc9dc504320bff9d696b002"

CONFLICTS = "xxf86dgaext"
