require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "76ca1c6e1d8904d2d885f81f7332eba6"
SRC_URI[archive.sha256sum] = "08069e1b7dd0e357c1ac7fa63aadcae094dc131d2a578eb1600a9bd16b8fde19"
