require xorg-proto-common.inc

PE = "1"

SRC_URI[archive.md5sum] = "aa948a7469168ddd9c33f11c5dff55ac"
SRC_URI[archive.sha256sum] = "9b6db77037de7c52b9a17862b99bc435bd5c20e5d3faf5aec943b206cdaff3ed"
