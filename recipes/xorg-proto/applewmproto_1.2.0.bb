require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "44e18d01857f9dfeb8628e317e786f31"
SRC_URI[archive.sha256sum] = "4f549083df9db85e61d0b272645e3dc71bacde9b9156ca20a57440e794b71042"
