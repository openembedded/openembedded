require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "3dfbd17203c0c88b94b6f579f24c11cc"
SRC_URI[archive.sha256sum] = "2f5d84413853b688b7bb46c66fee108a499190e1f7810afffb775910778f053c"
