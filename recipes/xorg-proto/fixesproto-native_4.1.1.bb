require fixesproto_${PV}.bb

PR = "r1"


inherit native
