require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "75c9edff1f3823e5ab6bb9e66821a901"
SRC_URI[archive.sha256sum] = "8224da1ce19c0ded4e07a325f3ed62bb4453782db97fd175cb3ffd1acaeb9672"

