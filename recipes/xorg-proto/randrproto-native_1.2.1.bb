require xorg-proto-common.inc

CONFLICTS = "randrext"
PR = "r1"
PE = "1"

inherit native 

XORG_PN = "randrproto"
