require xorg-proto-common.inc

PE = "1"

SRC_URI[archive.md5sum] = "e6841018a7c64983b0954aa2c564d115"
SRC_URI[archive.sha256sum] = "d33e1f3c96daad78667b2dfc14a1ce2ee3bdce19409f82cd5ede6c696ca5b042"
