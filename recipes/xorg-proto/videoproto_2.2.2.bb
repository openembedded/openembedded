require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "44292d74a9a3c94b1ecb9d77a0da83e8"
SRC_URI[archive.sha256sum] = "ab088478830cd30c2fe34fb7f44ffd4d177af7711c225c24676d3e9e9f24780c"
