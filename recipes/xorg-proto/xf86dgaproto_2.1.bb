require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "a036dc2fcbf052ec10621fd48b68dbb1"
SRC_URI[archive.sha256sum] = "ac5ef65108e1f2146286e53080975683dae49fc94680042e04bd1e2010e99050"

CONFLICTS = "xxf86dgaext"
