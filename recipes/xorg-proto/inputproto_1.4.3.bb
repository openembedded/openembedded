require xorg-proto-common.inc

PE = "1"

SRC_URI[archive.md5sum] = "a0f0d8cf6fbf0db8ba3937d0cc16138d"
SRC_URI[archive.sha256sum] = "627119ff21391314b88e5f34da837473151a54ab980d2f76d7f3c6bd3d560d4a"
