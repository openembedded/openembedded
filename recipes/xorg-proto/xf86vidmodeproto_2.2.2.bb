require xorg-proto-common.inc

CONFLICTS = "xxf86vmext"
PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "f00844a63d6e76b69eb0eb5e41eed843"
SRC_URI[archive.sha256sum] = "07152f990cc79ec5931989decc4a90b1919147e98ff6fcfe39507a9d3fc4d96e"
