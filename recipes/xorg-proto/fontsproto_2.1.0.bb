require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "f3a857deadca3144fba041af1dbf7603"
SRC_URI[archive.sha256sum] = "5a9af61dc9142488c9ba6e4ae30a9d970ea0f889a1ab7f59de1c1898c83aeb35"
