require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "d80acad88411e7944b9b085463d53302"
SRC_URI[archive.sha256sum] = "aaa6d9c9d5ec58f733ca4d7413c541413482bce666217267e5bf88442e35fce2"
