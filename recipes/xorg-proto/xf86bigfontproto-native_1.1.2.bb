require xf86bigfontproto_${PV}.bb
require xorg-proto-native.inc

PR = "r1"

XORG_PN = "xf86bigfontproto"
