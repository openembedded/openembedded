require xorg-proto-common.inc
PE = "1"

#DESCRIPTION = ""

SRC_URI[archive.md5sum] = "563cc41eeb590cf5eb2127807b838dfc"
SRC_URI[archive.sha256sum] = "913ff534aa777e3c36f3e9fe3e8638c3ccfe398daeb7532fa917e7bcd6fed07d"
