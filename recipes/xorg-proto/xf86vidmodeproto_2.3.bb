require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "4434894fc7d4eeb4a22e6b876d56fdaa"
SRC_URI[archive.sha256sum] = "8f704613a5407b31c594d05cf8e053f2b05777172a44e7cd2abd8090bd2ac247"

CONFLICTS = "xxf86vmext"
