require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "78e7c4dc7dcb74b1869fee7897e00f59"
SRC_URI[archive.sha256sum] = "fe481d89d74f01db4f3a671ef1f29df29da74dff5b678517ee659a6f9d819451"
