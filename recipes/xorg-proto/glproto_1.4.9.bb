require xorg-proto-common.inc

PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "e60951628422663e60faeb400f27bac1"
SRC_URI[archive.sha256sum] = "69d7fb7be4f0f56bd3a67b6c8c88dc677892eb99fd1b13e166b43b39d64764a3"
