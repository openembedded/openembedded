require fontcacheproto_${PV}.bb

PR = "r1"

XORG_PN = "fontcacheproto"

inherit native

SRC_URI[archive.md5sum] = "a8a50e5e995bfacb0359575faf7f6906"
SRC_URI[archive.sha256sum] = "1dcaa659d416272ff68e567d1910ccc1e369768f13b983cffcccd6c563dbe3cb"
