require libeventdb.inc

PR = "r1"

SRC_URI[md5sum] = "b8612abfa0f7c104980bc5f11df5c6a5"
SRC_URI[sha256sum] = "cf658f4be3e8ff301f1539b70a8c31f5a7e4893344cf7ea9f7abae12a0a53baf"
