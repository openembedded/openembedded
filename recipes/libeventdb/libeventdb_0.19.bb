require libeventdb.inc

PR = "r1"

SRC_URI[md5sum] = "89e7e82ee764cadd21ec35e5b66f5009"
SRC_URI[sha256sum] = "dd62e0614bef0de870b4626af398040ce8c5a29b59575625c079482443bd557d"
