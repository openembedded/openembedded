require libeventdb.inc

PR = "r2"
SRC_URI += "file://libeventdb-unbreak-LIVE-macro.patch;patch=1"

SRC_URI[md5sum] = "fd7975bb5f3ddb46e6f318e69c3d92d4"
SRC_URI[sha256sum] = "b3bc81803e890514e9e0ed491c05af701dfc58e985b071a4a408ba99dd858180"
