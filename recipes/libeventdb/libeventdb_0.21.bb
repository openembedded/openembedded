require libeventdb.inc

PR = "r1"

SRC_URI[md5sum] = "6f04df7771c575d5ec087de14669c810"
SRC_URI[sha256sum] = "b6fa6a83fde364d69cc4592da45aa9b2016c843679f3c1421a57b5629a9bd170"
