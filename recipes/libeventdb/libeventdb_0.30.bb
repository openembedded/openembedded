require libeventdb.inc

PR = "r1"
DEFAULT_PREFERENCE = "-1"

SRC_URI[md5sum] = "aeab2ac484b9cbb5a950f1f4ca2a32ad"
SRC_URI[sha256sum] = "2905109d2331bdb1ad82b3e3386f78315182e6b4cfb52661b9b52d123730ddef"
