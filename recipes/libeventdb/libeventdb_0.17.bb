require libeventdb.inc

PR = "r1"

headers = "event-db.h"

SRC_URI[md5sum] = "61a3bc3b4e33b01142b0d18cbef42f4c"
SRC_URI[sha256sum] = "fcf56cc61742ed09b285cf11b3a67bd64689b503adc6b5681124fda26ab58aee"
