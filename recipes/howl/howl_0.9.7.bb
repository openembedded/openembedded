SRC_URI = "http://www.porchdogsoft.com/download/howl-${PV}.tar.gz"
LICENSE = "howl"

inherit autotools


SRC_URI[md5sum] = "85fbe016e2ebad99108b1212ae4b1d6f"
SRC_URI[sha256sum] = "f8766c44291aac92b2b4abc762e1b11e3504dd9f2a855fdde371b5abd730fe9f"
