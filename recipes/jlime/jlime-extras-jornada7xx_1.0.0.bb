DESCRIPTION = "Various extras for the HP Jornada 7xx"
PR = "r0"

COMPATIBLE_MACHINE = "jornada7xx"

PACKAGE_ARCH = "all"

ALLOW_EMPTY = 1
