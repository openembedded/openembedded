DESCRIPTION = "Various extras for the NEC Mobilepro 900/c"
PR = "r0"

COMPATIBLE_MACHINE = "mp900c"

PACKAGE_ARCH = "all"

ALLOW_EMPTY = 1
