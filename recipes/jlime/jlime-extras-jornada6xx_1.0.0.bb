DESCRIPTION = "Various extras for the HP Jornada 6xx"
PR = "r0"

COMPATIBLE_MACHINE = "jornada6xx"

PACKAGE_ARCH = "all"

ALLOW_EMPTY = 1
