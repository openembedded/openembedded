require anki.inc

PR = "r1"

S = "${WORKDIR}/anki-${PV}/libanki"
