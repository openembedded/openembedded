require hal-info.inc

SRC_URI[md5sum] = "c7005ccb1765d8359fd2348350770495"
SRC_URI[sha256sum] = "bec1b0ad166b6c4d5269e7aa6d7bdbd0eb05c8f2c30042e4dca18993ba5682f0"
