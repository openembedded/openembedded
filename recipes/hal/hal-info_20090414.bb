require hal-info.inc

SRC_URI[md5sum] = "ae7177ab8f0163d3ef2df71f0de2b357"
SRC_URI[sha256sum] = "33dd87dc9452227375b8b9cdad940581714a55d55ff18ae2990905ac2f81fa0f"
