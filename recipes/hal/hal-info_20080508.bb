require hal-info.inc

SRC_URI[md5sum] = "6fc99d15d38945c17a291ea93e664664"
SRC_URI[sha256sum] = "80655b3531ea56a5d64085e572dfb8d3ecabffd28af482cd130f72dfdd6254b0"
