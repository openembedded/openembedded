require poppler.inc

DEFAULT_PREFERENCE = "-1"
DEFAULT_PREFERENCE_angstrom = "1"

EXTRA_OECONF_append = " --disable-abiword-output "


SRC_URI[md5sum] = "28f9dbdc74e9aadbf27aff16d06f4990"
SRC_URI[sha256sum] = "2ec40a8d9d9b80ebebea594c407c31962845376287c19e37345371236ed180d5"
