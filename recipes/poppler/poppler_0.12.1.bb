require poppler.inc

DEFAULT_PREFERENCE = "-1"
DEFAULT_PREFERENCE_angstrom = "1"

EXTRA_OECONF_append = " --disable-abiword-output "


SRC_URI[md5sum] = "3432046ee111efa5b85e5f2cdde8af5c"
SRC_URI[sha256sum] = "6316a3618efd411e34a48a102a1949b1fdcc562f6e69c4d28f0669913451bbb6"
