require poppler.inc

PR = "r0"

EXTRA_OECONF_append = " --disable-abiword-output "


SRC_URI[md5sum] = "13d12ca4e349574cfbbcf4a9b2b3ae52"
SRC_URI[sha256sum] = "54269075e4d611a61792a374986e920744c8ca39c2df45911233873c7e714354"
