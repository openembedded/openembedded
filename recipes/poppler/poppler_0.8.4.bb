require poppler.inc

PR = "r0"

EXTRA_OECONF_append = " --disable-abiword-output "


SRC_URI[md5sum] = "29d341f295d01bff64c63a29a6abb274"
SRC_URI[sha256sum] = "45bd5740b07e6c15db9859a5ee82e2acc9eeec62be537735ae5872fc3648257a"
