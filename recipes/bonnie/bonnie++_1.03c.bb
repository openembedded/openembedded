require bonnie++.inc

SRC_URI[md5sum] = "77a1ba78f37bdd7f024b67e1e36ad151"
SRC_URI[sha256sum] = "c674f1182f4c20f1e6d038feceb0a6617fc3e7658dfbbac89396043b49612a26"
