inherit qt4e

require qextserialport.inc

