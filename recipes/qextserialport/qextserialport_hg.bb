inherit qt4x11

require qextserialport.inc

