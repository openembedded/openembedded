require xtrans_${PV}.bb

DEPENDS = "util-macros-sdk"

inherit sdk

SRC_URI[archive.md5sum] = "8b36cdf08df12be96615e3d550236626"
SRC_URI[archive.sha256sum] = "765219fa822edeffb0650e93458e4ebf63c23176e58fce06806fb251fbfe7d8c"
