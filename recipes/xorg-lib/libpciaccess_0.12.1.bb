require xorg-lib-common.inc
DEPENDS += "xproto virtual/libx11"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "d6363ee9f4df79f6fc47cba7c67b0d35"
SRC_URI[archive.sha256sum] = "cc47d7f0e48cf4eed972916b536fdc97788d7521915e3ae1cc92d540776d7344"
