require xorg-lib-common.inc

DEPENDS += "xproto virtual/libx11"

PR="r1"

SRC_URI[archive.md5sum] = "685cb20e7a6165bc010972f1183addbd"
SRC_URI[archive.sha256sum] = "5ccb9683b8be76edfceab4bf006e1cce9018e0d3dea5e54aa72e82798213fead"
