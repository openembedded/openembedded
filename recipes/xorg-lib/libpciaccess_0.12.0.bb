require xorg-lib-common.inc
DEPENDS += "xproto virtual/libx11"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "285e07976274572e1f1e68edee09b70a"
SRC_URI[archive.sha256sum] = "f6b3c00e1c0aab0729563115d3d798e14c9210b4e10fccb484efe1c5eae85657"
