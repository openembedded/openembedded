require xorg-lib-common.inc

DEPENDS += " virtual/libx11"
PE = "1"

XORG_PN = "liboldX"

SRC_URI[archive.md5sum] = "6b81ffe486d76c380d08f92285758d84"
SRC_URI[archive.sha256sum] = "1091d301f5e28f84e5d755a5cde9d2f7edb82b799d051522751874571e10340f"
