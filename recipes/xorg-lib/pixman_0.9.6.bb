require pixman.inc
PR = "${INC_PR}.0"
S = "${WORKDIR}/pixman-${PV}"

SRC_URI[archive.md5sum] = "d2b1071cdbb0b8da18039111ba2dfd22"
SRC_URI[archive.sha256sum] = "179abc613f5100081cdef833f24a35fe7b646b8a4f0c79647d9609f6bf8222d8"
