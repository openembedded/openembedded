require libxrender_${PV}.bb

DEPENDS = "libx11-native renderproto-native"
PE = "1"

inherit native
