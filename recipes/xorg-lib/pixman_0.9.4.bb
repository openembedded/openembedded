require xorg-lib-common.inc

DESCRIPTION = "Library for lowlevel pixel operations"
DEPENDS = "virtual/libx11"
PR = "r0"


SRC_URI[archive.md5sum] = "c354ab5b0da10227226d3ef604254875"
SRC_URI[archive.sha256sum] = "261d239e9e3070a0a81e5b3eab92e6236c6295979bdae0a1ded05cbef93f67aa"
