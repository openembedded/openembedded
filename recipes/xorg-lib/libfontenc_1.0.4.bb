require xorg-lib-common.inc

DESCRIPTION = "X11 font encoding library"
LICENSE = "BSD-X"
DEPENDS += "zlib xproto"
PR = "r1"
PE = "1"

SRC_URI[archive.md5sum] = "5cd16a2e51ca7b96a3081c7486ff98b9"
SRC_URI[archive.sha256sum] = "b993aa3d17e845a12a49160b5d96993059ce919c7ba902005b910b867b6258c8"
