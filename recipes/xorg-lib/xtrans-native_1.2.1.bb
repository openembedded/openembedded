require xtrans_${PV}.bb

DEPENDS = "util-macros-native"

inherit native

SRC_URI[archive.md5sum] = "96e142331edd498a9364887b2548f1bb"
SRC_URI[archive.sha256sum] = "9ff21a8d9ea524ca9b7cb6d6b4d522b4cb20b1c35edeb8995a9e9265a0df64bd"
