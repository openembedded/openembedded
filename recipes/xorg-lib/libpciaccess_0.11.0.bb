require xorg-lib-common.inc

DEPENDS += "xproto virtual/libx11"

PR="r1"

SRC_URI[archive.md5sum] = "686320dcec98daad0bdfb8894d4f2a2b"
SRC_URI[archive.sha256sum] = "6e38be12b656c83c66a6fd8ba56c041d8188218278219c88ee635242ec1c7dab"
