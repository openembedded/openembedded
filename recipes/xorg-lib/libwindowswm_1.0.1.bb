require xorg-lib-common.inc

DEPENDS += "libxext windowswmproto"
PE = "1"

XORG_PN = "libWindowsWM"

SRC_URI[archive.md5sum] = "274b2b5620a524fd7bb739edb97317f5"
SRC_URI[archive.sha256sum] = "25f07cf847cbe91d36c20f348b4b9494c4504fe02966e8cdf65cf56316a70edc"
