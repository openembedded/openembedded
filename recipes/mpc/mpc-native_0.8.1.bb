require mpc_${PV}.bb
inherit native
DEPENDS = "mpfr-native gmp-native"
