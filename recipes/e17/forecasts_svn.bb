LICENSE = "MIT"
PV = "0.2.0+svnr${SRCREV}"

require e-module.inc




