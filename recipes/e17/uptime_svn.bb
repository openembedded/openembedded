LICENSE = "MIT"
PV = "0.0.2+svnr${SRCREV}"

require e-module.inc




