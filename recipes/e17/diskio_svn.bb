LICENSE = "MIT"
PV = "0.0.1+svnr${SRCPV}"

require e-module.inc




