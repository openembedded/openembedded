require vpnc.inc

PR = "r1"

SRC_URI = "http://www.unix-ag.uni-kl.de/~massar/vpnc/vpnc-${PV}.tar.gz"

SRC_URI[md5sum] = "aaccdffc5656095a45dfe87c5bf612cb"
SRC_URI[sha256sum] = "55702637d377d73e6f323462779aeb02f5049d71c7ea4e3bbe564566d9a8d488"
