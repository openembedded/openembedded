require libxslt.inc
PR = "${INC_PR}.0"
SRC_URI[archive.md5sum] = "e61d0364a30146aaa3001296f853b2b9"
SRC_URI[archive.sha256sum] = "55dd52b42861f8a02989d701ef716d6280bfa02971e967c285016f99c66e3db1"
