SQUID_MAJOR = "2.7"

include squid-native.inc

SRC_URI[squid-2.7.STABLE8.md5sum] = "c061ba1c9ae39d0aaa8eca137f7dd18b"
SRC_URI[squid-2.7.STABLE8.sha256sum] = "9409b02fc53518e334395df803a1ae30f4ed385b0f041fb310b4c75e2a49138c"