DESCRIPTION = "Virtual package including the whole gEDA suite"
LICENSE = "GPLv2"
HOMEPAGE = "http://geda.seul.org"

DEPENDS = "libgeda gtk+"
RRECOMMENDS = "geda-utils geda-gattrib geda-gnetlist geda-gschem geda-gsymcheck geda-symbols geda-docs geda-examples"
