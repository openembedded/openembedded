DESCRIPTION = "xdg-utils: command line tools for desktop integration tasks"
LICENSE = "MIT"

SRC_URI = "http://portland.freedesktop.org/download/${PN}-${PV}.tgz"

inherit autotools

