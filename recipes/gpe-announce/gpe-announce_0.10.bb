SECTION = "gpe"
LICENSE = "GPL"
inherit gpe

DEPENDS = "libsoundgen libschedule gtk+ libgpewidget"

SRC_URI[md5sum] = "3791be9e14d08687fff3d6520cbd4e09"
SRC_URI[sha256sum] = "a332aa05f21c9e977cf07bbe0a9a81e64fa0e3f8b807531609448f09976d8b2a"
