inherit gpe

DEPENDS = "libsoundgen libschedule gtk+ libgpewidget"
LICENSE = "GPL"


SRC_URI[md5sum] = "111714426410274e8ba1a9abe2804d90"
SRC_URI[sha256sum] = "8895c046511d06c47dcc8d8608cb220e0b608cede1ea169174ab3bc451d111c5"
