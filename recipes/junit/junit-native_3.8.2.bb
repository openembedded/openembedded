require junit_${PV}.bb

inherit java-native

