require junit4_${PV}.bb

inherit java-native

