require bug-osgi.inc
PR = "${INC_PR}.3+svnr${SRCREV}"
