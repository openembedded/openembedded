require bug-osgi.inc
PR = "${INC_PR}.1+svnr${SRCREV}"
DEPENDS += "com.buglabs.common service-tracker com.buglabs.osgi.http com.sun.javax.servlet"
