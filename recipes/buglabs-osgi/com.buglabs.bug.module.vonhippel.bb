require bug-osgi.inc
PR = "${INC_PR}.11+svnr${SRCREV}"
DEPENDS += "com.buglabs.common  com.buglabs.bug.module com.buglabs.bug.jni.vonhippel com.buglabs.bug.jni.common felix-configadmin com.buglabs.bug.jni.rxtx openjdk-6"
