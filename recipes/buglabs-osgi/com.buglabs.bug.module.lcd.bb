require bug-osgi.inc
PR = "${INC_PR}.4+svnr${SRCREV}"
DEPENDS += "com.buglabs.bug.base com.buglabs.common com.buglabs.bug.jni.accelerometer com.buglabs.bug.module com.buglabs.bug.jni.lcd com.buglabs.bug.jni.common" 
