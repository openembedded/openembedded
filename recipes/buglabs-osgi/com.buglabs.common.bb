require bug-osgi.inc
PR = "${INC_PR}.9+svnr${SRCREV}"
DEPENDS += "felix-configadmin"
