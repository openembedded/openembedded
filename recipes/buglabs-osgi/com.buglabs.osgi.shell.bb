require bug-osgi.inc
PR = "${INC_PR}.5+svnr${SRCREV}"
DEPENDS += "com.buglabs.common"
