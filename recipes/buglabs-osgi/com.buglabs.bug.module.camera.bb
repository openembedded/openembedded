require bug-osgi.inc
PR = "${INC_PR}.2+svnr${SRCREV}"
DEPENDS += "com.buglabs.common  com.buglabs.bug.module com.buglabs.bug.jni.camera com.buglabs.bug.jni.input com.buglabs.bug.jni.common" 
