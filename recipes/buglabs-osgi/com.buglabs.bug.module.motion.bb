require bug-osgi.inc
PR = "${INC_PR}.5+svnr${SRCREV}"
DEPENDS += "com.buglabs.common  com.buglabs.bug.module com.buglabs.bug.jni.motion com.buglabs.bug.jni.accelerometer com.buglabs.bug.jni.common felix-configadmin" 
