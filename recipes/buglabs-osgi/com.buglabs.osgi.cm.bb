require bug-osgi.inc
PR = "${INC_PR}.2+svnr${SRCREV}"
