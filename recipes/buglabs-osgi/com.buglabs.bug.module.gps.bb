require bug-osgi.inc
PR = "${INC_PR}.5+svnr${SRCREV}"
DEPENDS += "com.buglabs.common  com.buglabs.bug.module com.buglabs.bug.jni.gps com.buglabs.nmea com.buglabs.bug.jni.common felix-configadmin"
