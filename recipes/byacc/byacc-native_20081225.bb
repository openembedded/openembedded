PR = "r0"

require byacc.inc

inherit native
