require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "a2b3951dbc6ddb2e4c7e09519dd13333"
SRC_URI[archive.sha256sum] = "8156f7c4e5a3fbd478c287154c7e3c55c6631c148a7b185f604753d118018da9"
