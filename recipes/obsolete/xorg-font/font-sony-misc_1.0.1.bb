require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "7b6f5117814599b86ed3470de6c62aa3"
SRC_URI[archive.sha256sum] = "da9526844c74ce395d3912d3d8f538cd57102d6bcd9f73fd0a5dccf53bfc56ca"
