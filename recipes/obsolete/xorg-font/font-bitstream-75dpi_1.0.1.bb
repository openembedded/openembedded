require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "aed54fb53d2d24aff10c92985286d1e5"
SRC_URI[archive.sha256sum] = "cf9e1cb1c21517a566e5678791778d40c7c915d792bd29d319928f4e4234662b"
