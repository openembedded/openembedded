require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "05714516824c680ce747c6ef9d2fbbdd"
SRC_URI[archive.sha256sum] = "fb20da4afddc07e236e830939de0fdfc9a93c5c1c7048fafe669fac19b496552"
