require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "c79d7921d95b2c4f10fad464bb121090"
SRC_URI[archive.sha256sum] = "dafafbfd93d95820449972fd86ec312266eb73e5297966ee6e0163d294d8af75"
