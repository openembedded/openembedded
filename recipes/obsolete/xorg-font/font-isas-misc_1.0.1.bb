require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "88b5b32c5a27576e9d00675bcc966806"
SRC_URI[archive.sha256sum] = "52fe0469eb91e94dc7a0e8164e947fee439f398b0eb63c210f682524f12cea7b"
