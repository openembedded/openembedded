require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "8af580b87e17ddacdf0ce3d775248387"
SRC_URI[archive.sha256sum] = "c46d68487b09993266f34ac87a47e035af8a3f42c38f33d26ff18ac0c31c3397"
