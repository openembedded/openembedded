require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "a4e8e229a051c0ede9eb525e4006d93a"
SRC_URI[archive.sha256sum] = "51027cc1d49140153620c1a2b653f1773fe92cb694b221396d68265343e113ab"
