require xorg-font-common.inc

DESCRIPTION = "100dpi, 24 point (approximately) font to minimally support (almost) all \
of the Arabic characters available in Unicode."

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "817ceb99636c873ad7679fe2a468678d"
SRC_URI[archive.sha256sum] = "f4b0305afd47844d337a87d03aab4359b576dc36464317f86541324ee6ea6f60"
