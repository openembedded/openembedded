require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "53785d2688392aec5cba79fc0ddb23a2"
SRC_URI[archive.sha256sum] = "8a3175a977f169f0882054ac5bf86c97bfee1dc031415092f75b2cfb57b69d40"
