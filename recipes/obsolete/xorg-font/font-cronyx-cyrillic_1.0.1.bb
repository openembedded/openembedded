require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "15f86f5e572df21218617982eb4b3bfc"
SRC_URI[archive.sha256sum] = "f7b43a428afe3111513e8ff0ebccc00fbddf2b57cec261ad9017d582fc9a3422"
