require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "4c88c79b8e5d47af90b21e948d42755f"
SRC_URI[archive.sha256sum] = "bf3b3a994b6c4047b2d79f590e7113ed429b8b7a83992cb753a83e6e8bd3d948"
