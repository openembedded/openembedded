require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "6397062f2b346ce5bbe5472f3353a9a9"
SRC_URI[archive.sha256sum] = "20ff9c5914c6916c96647eeb3ba700468952fdf01925e62516219a7dd6eb3841"
