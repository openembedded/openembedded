require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "05597e2b193a7b7de2ca525468276b1d"
SRC_URI[archive.sha256sum] = "e2283e4280c66fec7c986f0b4a476811f3419b9517280cd8b59a01563de6e491"
