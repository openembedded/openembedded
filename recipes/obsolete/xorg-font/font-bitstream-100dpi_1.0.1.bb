require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "3b8748f8029c53595e4a4a1b23fa790a"
SRC_URI[archive.sha256sum] = "3e05c9b74d0dc00e6e46ec758888e66514ab24fc75930877d4ba6db7d49f0347"
