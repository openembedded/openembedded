require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "a966f5a8aade9e63af86d8a6bf3e8586"
SRC_URI[archive.sha256sum] = "7a026aeaafe5a619b2c1b35cd361125b169b2212eaf0f2f5ce796038b1cf06cd"
