require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "c754c3f4a5e08442bf6972b9466625ed"
SRC_URI[archive.sha256sum] = "a742bca8d6f8fb76b511f11c2ad2a1d326687fe9f0490a9cf64524c3782cb52c"
