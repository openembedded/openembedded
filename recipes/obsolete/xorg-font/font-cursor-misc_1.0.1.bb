require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "13c21c4d74155c662152a1a74f249d96"
SRC_URI[archive.sha256sum] = "deee02861beaa335448e9aba4320c88c30a174bc3dcfb05a434b4ddb137dc1b3"
