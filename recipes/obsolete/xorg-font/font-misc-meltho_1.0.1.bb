require xorg-font-common.inc

DESCRIPTION = "These fonts are designed for the display of Syriac text."
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "345f1a78312e30cd2c41d24ea3f3276f"
SRC_URI[archive.sha256sum] = "5366d7a0f38a189e504676a9cddd8430113f9957919f0a3dc181bcaaaed92618"
