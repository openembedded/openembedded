require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "374d954c61363206c93d1ce7e9445c31"
SRC_URI[archive.sha256sum] = "da3b5f26c6cde0baf3831f50c79a7a107806f885e0205073855bfbc5a357bb45"
