require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "1646179ff224b3e2c9b1e7f59042897f"
SRC_URI[archive.sha256sum] = "887ea895cc0fdd5c50d4960aee7cb6ed813cf90f53b53ce0e0e068dd606cc919"
