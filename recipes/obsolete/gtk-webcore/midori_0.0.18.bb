require midori.inc

PR = "r2"

SRC_URI += "file://desktop.patch;patch=1"


SRC_URI[md5sum] = "aa9c10bbf6fe3502a65633c4fac0fb80"
SRC_URI[sha256sum] = "36c20ca7c59e6c35deb04a9febde8aa8040c78c6ba21f595442b94ab78ec137c"
