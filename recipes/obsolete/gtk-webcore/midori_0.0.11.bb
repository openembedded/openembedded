require midori.inc           

SRC_URI[md5sum] = "dea8fba05c35333c0c984745cb397acb"
SRC_URI[sha256sum] = "f3b82db4c4edd81087aa37e747501af903dfd2d1e6e2063f20a345e4e7924116"
