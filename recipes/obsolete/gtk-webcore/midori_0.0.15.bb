require midori.inc           

SRC_URI[md5sum] = "0b6eebdcedd224b2b9f437b706471762"
SRC_URI[sha256sum] = "3b449713a164d574031843ca38f37be12e3ac40804995b3e5a252562a598482f"
