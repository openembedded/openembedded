require midori.inc           

SRC_URI[md5sum] = "f69826ece3b8a34ef431d2de57b60d96"
SRC_URI[sha256sum] = "13831ee98f4daaee9b5569a6ac8924a1e5f3223b928f408ab7e8b013daa4921c"
