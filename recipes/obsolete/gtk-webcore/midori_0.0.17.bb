require midori.inc           

SRC_URI += "file://webkit-update.patch;patch=1"



SRC_URI[md5sum] = "58d1b7ed282540030eb1b5803b760865"
SRC_URI[sha256sum] = "affeddb78d9342e961e868270872c166ac2eba7d43e5f629d91f03219d6e0df8"
