require midori.inc



SRC_URI[md5sum] = "7a4a20e21fb3f3109c81f6ff9cc4647e"
SRC_URI[sha256sum] = "b79b8aad657d2a2b59fb773fed4ef7567fb28e5a3f3bd645ff904f69d50a0555"
