require midori.inc           

SRC_URI[md5sum] = "e67bc748c11606013a90a0760a843967"
SRC_URI[sha256sum] = "5261c2e9d7a3d10832bedf3970dad89d8c9e39b54269111d719c6e60aa422aac"
