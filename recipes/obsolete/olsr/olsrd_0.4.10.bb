require olsrd.inc
PR = "r1"

SRC_URI[md5sum] = "9807d4451e65cb4ec385155eef7bf3cf"
SRC_URI[sha256sum] = "af04bdd8abd85bb4715fd6011566054847c75fcbac5e5e9cdee80858ac2957d3"
