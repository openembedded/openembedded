require xorg-app-common.inc
DEPENDS += " libfs"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "a61be25c87ee42169ee4dc8344acc9e2"
SRC_URI[archive.sha256sum] = "9c8e7d573284272c633b5cf18e3358830b27bde72f4bc1ae83a1ab337d463a92"
