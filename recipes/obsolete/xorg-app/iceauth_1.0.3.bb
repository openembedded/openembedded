require xorg-app-common.inc
DESCRIPTION = "a tool for manipulating ICE protocol authorization records"
DEPENDS += " libice"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "975ade3f238c1eb10705da0a91e6e8e7"
SRC_URI[archive.sha256sum] = "abca3ff6c9f2da2600a474f0e92ae5e62c43914f7bd3d948b91b0a7f9117d81e"
