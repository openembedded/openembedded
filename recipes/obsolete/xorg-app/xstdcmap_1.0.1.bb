require xorg-app-common.inc
DEPENDS += " libxmu "
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "86ab558441edfb86f853639e4290a754"
SRC_URI[archive.sha256sum] = "0d920660137dee514599f63b5a8c8ce14d2474607e28e32c973cafb360f7e738"
