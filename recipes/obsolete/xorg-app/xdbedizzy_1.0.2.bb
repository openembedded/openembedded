require xorg-app-common.inc
DEPENDS += " libxp libxprintutil libxp libxau libxext"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "ecef9cfd197d00980e0d69ee4126d890"
SRC_URI[archive.sha256sum] = "74e882e9fee7ebeb274caf43071afff92531b8a41f34650376146a131166012d"
