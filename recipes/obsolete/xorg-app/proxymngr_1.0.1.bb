require xorg-app-common.inc
DEPENDS += " libice libxt xproxymanagementprotocol"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "aad44d0f65b97fd6d564b1d2ae510bb1"
SRC_URI[archive.sha256sum] = "e9f5d4553411562477a0605fb0f0ec728016499e37230138a5e207dec79525c5"
