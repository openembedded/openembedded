DESCRIPTION = "An example panel plugin for Openmoko"
SECTION = "openmoko/examples"
DEPENDS += "libmatchbox"
SRCREV = "1622"
PV = "0.0.1+svnr${SRCPV}"

inherit openmoko

PARALLEL_MAKE = ""

