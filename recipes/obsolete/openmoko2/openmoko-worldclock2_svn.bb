DESCRIPTION = "A World-Clock for Openmoko"
SECTION = "openmoko/tools"
DEPENDS = "libmokoui2 libjana"
SRCREV = "3365"
PV = "0.1.0+svnr${SRCPV}"

inherit openmoko2
