COLLIE_MEMORY_SIZE = "64"
COLLIE_RAMDISK_SIZE = "0"

require ../linux/openzaurus-sa_2.4.18-rmk7-pxa3-embedix20030509.bb
