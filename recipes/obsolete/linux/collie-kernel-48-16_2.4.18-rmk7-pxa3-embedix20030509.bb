COLLIE_MEMORY_SIZE = "48"
COLLIE_RAMDISK_SIZE = "16"

require ../linux/openzaurus-sa_2.4.18-rmk7-pxa3-embedix20030509.bb
