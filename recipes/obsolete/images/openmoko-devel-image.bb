require openmoko-image.bb

IMAGE_INSTALL += "task-openmoko-debug"
