require openmoko-devel-image.bb

IMAGE_INSTALL += "task-openmoko-native-sdk"
