DESCRIPTION = "Shows the wifi status in the Openmoko panel"
DEPENDS = "libmokopanelui2"
SRCREV = "4344"
PV = "0.0.0+svnr${SRCPV}"

inherit openmoko-panel-plugin

