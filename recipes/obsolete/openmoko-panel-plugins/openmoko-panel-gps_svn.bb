DESCRIPTION = "Shows the GPS status in the Openmoko panel"
DEPENDS = "gpsd"
SRCREV = "4330"
PV = "0.1.0+svnr${SRCPV}"

inherit openmoko-panel-plugin

