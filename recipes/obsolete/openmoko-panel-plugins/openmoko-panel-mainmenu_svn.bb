DESCRIPTION = "Main menu applet for the Openmoko panel"
DEPENDS += "pulseaudio startup-notification"
SRCREV = "2567"
PV = "0.1.0+svnr${SRCPV}"
PR = "r1"

inherit openmoko-panel-plugin

