require didiwiki.inc
