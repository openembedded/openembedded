require util-macros.inc
PR = "${INC_PR}.0"
SRC_URI[archive.md5sum] = "51bb54c08415ee3c3000b7df9e9b07c5"
SRC_URI[archive.sha256sum] = "57d2629849796b4dc919261eadd1eea3ee6e634d58979797287f7e09408cde67"
