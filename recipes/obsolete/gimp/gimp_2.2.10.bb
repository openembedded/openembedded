require gimp.inc
PR = "r1"

SRC_URI[archive.md5sum] = "aa29506ed2272af02941a7a601a7a097"
SRC_URI[archive.sha256sum] = "41f4befa851177e2ca9bbab2fad19926178c831454ca51f2cb91fec0ed9e243e"
