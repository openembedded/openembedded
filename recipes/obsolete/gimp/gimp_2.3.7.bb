require gimp.inc
PR = "r1"

SRC_URI[archive.md5sum] = "dfc47a29b3a7ade07bd17244f0e83311"
SRC_URI[archive.sha256sum] = "2a6c869ba61c1b18bbafa95bdf89cdc8fe1f07b068aa37dc9332a158b7e295eb"
