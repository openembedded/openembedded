require xorg-driver-input.inc
DESCRIPTION = "X.Org X server -- mouse input driver"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "fc4c99046af0be9d67f1f5a1911b6ed5"
SRC_URI[archive.sha256sum] = "1b3dcc3a012e0f490b800804c41240478267c13fd80101266bab98bc2c9c2a9e"
