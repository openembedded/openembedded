require xorg-app-common.inc
DEPENDS += " libxmu"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "69adcda848479acc3b82b3928812d191"
SRC_URI[archive.sha256sum] = "456d575a0cdb37fc9415578a3ad34ba3cf9eb5eb0f6e5a25f97ca41db416d55a"
