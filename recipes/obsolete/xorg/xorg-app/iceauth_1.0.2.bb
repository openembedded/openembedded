require xorg-app-common.inc
DESCRIPTION = "a tool for manipulating ICE protocol authorization records"
DEPENDS += " libice"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "7ab8b64edf0212a9d9a3c8129901a450"
SRC_URI[archive.sha256sum] = "06401591de57a2c4cf2255e3d5230ea19351c5516cf8dae98c61092392bab5bb"
