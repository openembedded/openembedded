require xorg-app-common.inc
DEPENDS += " libxaw libxt"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "058d168d1c7c991b8d12158433ea5f63"
SRC_URI[archive.sha256sum] = "1f239057cdfb2164b2e8fc229e2518d20b27a853f975e73618a4a81f09ebeb02"
