require xorg-app-common.inc
DEPENDS += " libfs"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "c7b2f8a938749d41dc86db6bd1e6a4ca"
SRC_URI[archive.sha256sum] = "3feb006a25f36856924e26249fe84b27142678f97175780960f085e1e263a62e"
