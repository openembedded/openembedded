require xorg-app-common.inc
DEPENDS += " libxmu "
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "0a6ef08a2ac08ad5c4dd1522eb3788a3"
SRC_URI[archive.sha256sum] = "ab8974e010c1957a9a65a54656215463dea324adcaa9954147ecdcc6e9307f61"
