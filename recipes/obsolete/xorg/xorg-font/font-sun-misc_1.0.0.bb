require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "e17d43a7c6c0d862cfba0908ff132ffa"
SRC_URI[archive.sha256sum] = "03c12d8f4d8e7f0178f501ea3ee0709ee3a1deda733afecd631807e6ba5729e5"
