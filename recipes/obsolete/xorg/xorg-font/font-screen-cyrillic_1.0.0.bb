require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "aea02d9dff03e0e1a3de85364367c0c6"
SRC_URI[archive.sha256sum] = "01de82644a9b765599ba8c36c6b689035a85b6590486842067f707f2cb0cf268"
