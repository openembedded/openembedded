require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "beb476657d50d07d17eef7c325a5ed08"
SRC_URI[archive.sha256sum] = "2ddfeaccca97524e1b0f4fb37b2fd0f1338698e35f8b05b22b594fe29e201bfb"
