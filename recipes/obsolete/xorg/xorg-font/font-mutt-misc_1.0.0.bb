require xorg-font-common.inc

DESCRIPTION = "Provides a 12pt, 100dpi proportional font with many of \
the glyphs needed for Unicode text."

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "648b409b7eb78ad1cd5f6d7fac3eef88"
SRC_URI[archive.sha256sum] = "f219183bd0f2b8ceca42a8a345c921f2a8ee19f4d86fef11c4ce8918d41aedff"
