require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "b99b02aff36a88ca3379715423c60303"
SRC_URI[archive.sha256sum] = "478a7f6881fce6a335b409e1326449af4162a147d268f1978b8dd81c834beee3"
