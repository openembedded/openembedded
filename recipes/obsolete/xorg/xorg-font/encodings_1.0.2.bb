require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

DEPENDS = "mkfontscale-native font-util-native"

SRC_URI[archive.md5sum] = "11adda157b03d63fd61d95ad7ef00466"
SRC_URI[archive.sha256sum] = "6d19107b66bbc96c085b0c2dd286ece22dcb73ba56a17fc95b0f2cbc5d6f4eac"
