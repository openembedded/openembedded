require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "0b271fc617087d77560bdca20c0cdbb0"
SRC_URI[archive.sha256sum] = "58d2868801ca063797fa88fb4aea59f7c550473be4e9a4f96d84fe39b967d141"
