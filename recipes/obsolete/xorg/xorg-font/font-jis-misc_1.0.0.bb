require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "61febb49a71065723a1fba17cbf23c67"
SRC_URI[archive.sha256sum] = "3721eefd4ffc47c6948065f7acf9d5c731c4e8e54105d096735876d3712dc7ba"
