require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "3596907d7a2a99c81d8de99bc4552b6a"
SRC_URI[archive.sha256sum] = "7c0bac1302129d3bf40ec7d9830e728b0251dc20dda8c8979227b478663290ff"
