require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "8e8733051371e2b51123376b49f5d3ea"
SRC_URI[archive.sha256sum] = "30d091c2e3506943f8a6e152c4be973c462ba19293a864bbb48b82c6cf9c461e"
