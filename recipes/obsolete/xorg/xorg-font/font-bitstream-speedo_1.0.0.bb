require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "1399dc18aeb9571b0951d9570ea1059d"
SRC_URI[archive.sha256sum] = "99ac01786ac400cc7407f1c427b92c5ff1ac5a31ce7d5907b7ad3c969214f6e6"
