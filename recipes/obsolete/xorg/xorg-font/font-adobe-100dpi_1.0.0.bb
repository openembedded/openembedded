require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "443acfe70e26716282f9068730fe92c4"
SRC_URI[archive.sha256sum] = "f16c1b3a1625c9a225aff2ac12067bd3907d157b0c60625689a5080f092e9a19"
