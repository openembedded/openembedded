require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "ad43cf739b3d46ba1e7dc778a0608a52"
SRC_URI[archive.sha256sum] = "7a1a5e72f7e42398b98d70aa64252837e85ed76eea77a1b9a4cd0f1203d7d644"
