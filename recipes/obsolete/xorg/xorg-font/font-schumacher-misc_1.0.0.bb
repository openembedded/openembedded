require xorg-font-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "f1c6063d2fadc57e696a0aab69afd6e0"
SRC_URI[archive.sha256sum] = "454e6cf885a4475569ce24ad3d4a82cb331d74e1a25f0747694a71098b56ef7a"
