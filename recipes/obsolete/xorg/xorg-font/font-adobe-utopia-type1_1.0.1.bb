require xorg-font-common.inc

DESCRIPTION = "Adobe typeface software"

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "aa7ff4bd20b961afda9c15d103b972a5"
SRC_URI[archive.sha256sum] = "e9c672c8ff275fd5c2d76dda9a9f11138766e246e31e45763cd7e14d8824c0dc"
