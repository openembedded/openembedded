require xorg-font-common.inc

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "ec709a96b64b497a5cb5658c93bd38dc"
SRC_URI[archive.sha256sum] = "97e61313ce0bf229da5d489fc5a05562fdca14f9acc17c40d0b272a345ba4ea2"
