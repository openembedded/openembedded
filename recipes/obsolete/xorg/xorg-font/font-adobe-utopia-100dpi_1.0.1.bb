require xorg-font-common.inc

DESCRIPTION = "Adobe typeface software"

PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "5d28a30efef966f8dbbaff9a6619f01a"
SRC_URI[archive.sha256sum] = "1943e1aa70c169b13bc7a308c8e949267f9ce6327479803203fbf10c06a9b5fe"
