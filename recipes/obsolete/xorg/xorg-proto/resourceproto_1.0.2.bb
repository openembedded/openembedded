require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "b823b314e37eb19dae1f297951d2e933"
SRC_URI[archive.sha256sum] = "0c33d6fceef5483001459bdc934b5831502250b27f1f4ad370ab044f8ab53487"

CONFLICTS = "resourceext"
