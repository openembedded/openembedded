require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "5d551850e6f4acdf49a13f4eb3a5bbfa"
SRC_URI[archive.sha256sum] = "db09abf73cc339c05c0488639731794372a4770cfca76c2645f503f9fccd478f"
