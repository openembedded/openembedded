require xorg-driver-input.inc
DESCRIPTION = "Mouse Support in X11"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "d8bcd9fb1b4efb02acd251495f9a30c1"
SRC_URI[archive.sha256sum] = "7d4c2ecbe8f9327f7c8093c05401ab68b22f3343bcf04e4838cc40c21b7f8e0a"
