require xorg-driver-input.inc
DESCRIPTION = "Mouse Support in X11"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "c47c598e55e7080b8ea30f70781f7ca3"
SRC_URI[archive.sha256sum] = "80e9cb52b2036b71289b2140bcd3ac202cf46fd42830761c53120ddac38e7edf"
