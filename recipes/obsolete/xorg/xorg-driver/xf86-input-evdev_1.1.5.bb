require xorg-driver-input.inc
DEPENDS += " kbproto"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "01705ea9a4d1699d5eeb17e7f297a581"
SRC_URI[archive.sha256sum] = "52b7daab86dade2d189f0378ddf196c018cdc9dd47ade0b3b8fc7591cb4bbe9e"
