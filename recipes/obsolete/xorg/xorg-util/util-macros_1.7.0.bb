require util-macros.inc
SRC_URI[archive.md5sum] = "8a8d208f24672e7a37d1aa4d2ffcef8e"
SRC_URI[archive.sha256sum] = "7a5519ca22cd6bc4664be7b52cc58d5594e9f18c282ee0f6f7c59c1dffabdd13"
PR = "${INC_PR}.0"
