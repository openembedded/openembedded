require util-macros.inc
PR = "${INC_PR}.0"
SRC_URI[archive.md5sum] = "ea2d9cd33ca6fd05923f007bd74d7c37"
SRC_URI[archive.sha256sum] = "97748154c41a1cd12635a79aee0c2846fd48ecb555fc8b54e3e5baec174e6e74"
