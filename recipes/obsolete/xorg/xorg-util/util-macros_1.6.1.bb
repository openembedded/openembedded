require util-macros.inc
SRC_URI[archive.md5sum] = "a4bef59dd4a2e3450c07c77c6b45a79f"
SRC_URI[archive.sha256sum] = "ba91652d78f2a63d69253fb80af2f0a76c2e1b081c64521f90fac3866ee893d7"
PR = "${INC_PR}.0"
