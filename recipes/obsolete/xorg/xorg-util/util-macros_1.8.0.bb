require util-macros.inc
PR = "${INC_PR}.0"
SRC_URI[archive.md5sum] = "fe73a69d02bd0be6cdf7c773bfd72041"
SRC_URI[archive.sha256sum] = "2de6954271dbd43f073022c371c15d5f1102a3631eaa4f4053bfd173e148f7d7"
