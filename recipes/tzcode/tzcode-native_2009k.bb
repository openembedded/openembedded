require tzcode-native.inc
SRC_URI = "ftp://elsie.nci.nih.gov/pub/tzcode${PV}.tar.gz \
	   ftp://elsie.nci.nih.gov/pub/tzdata2009n.tar.gz \
	  "
PR = "${INC_PR}.0"
