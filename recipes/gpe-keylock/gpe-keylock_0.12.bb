LICENSE = "GPL"
inherit gpe

DESCRIPTION = "GPE screen lock utility"
DEPENDS = "gtk+ libgpewidget"
SECTION = "gpe"
PRIORITY = "recommended"


SRC_URI[md5sum] = "933848f1db682edba169c34ea280a564"
SRC_URI[sha256sum] = "3904c2dcf6d309247e1f8138ffba94ecd1d14e48c1b9306beebcccb28dbbd87b"
