require exmap-console.inc

PR = "r5"

SRC_URI[md5sum] = "55aec784e214037e61400287a55b5426"
SRC_URI[sha256sum] = "53082354ae893fd385051c96214640cbeba527131ccf9f5320626252a4aef8d5"
