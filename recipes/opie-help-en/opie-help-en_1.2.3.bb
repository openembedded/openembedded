require ${PN}.inc

SRC_URI = "${HANDHELDS_CVS};tag=${PV};module=opie/help/en/html "
