require ${PN}.inc

PR = "r0"

SRC_URI = "http://sources.openembedded.org/opie-1.2.5-split_help_en_html.tar.bz2;name=split_help_en_html"
SRC_URI[split_help_en_html.md5sum] = "5ac74b5394fc9afa780f3925862496e3"
SRC_URI[split_help_en_html.sha256sum] = "64c9dd9aa72ea9939ee9176eb80a0b87d58b43bcdb5e652b581de93e52b506dc"
