require ${PN}.inc

PR = "r1"

TAG = "${PV}"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_help_en_html.tar.bz2"
