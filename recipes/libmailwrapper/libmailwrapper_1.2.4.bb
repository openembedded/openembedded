require ${PN}.inc

PR = "r1"

SRC_URI = "http://sources.openembedded.org/opie-1.2.4-split_noncore_net_mail_libmailwrapper.tar.bz2;name=split_noncore_net_mail_libmailwrapper"
SRC_URI[split_noncore_net_mail_libmailwrapper.md5sum] = "6dbf55b3c78d58f7f81aadb317c22f13"
SRC_URI[split_noncore_net_mail_libmailwrapper.sha256sum] = "5d9b6b471402a5b30d8dc2553ef0fdb8c05918c6c6de876eae791a614b3de4ff"
