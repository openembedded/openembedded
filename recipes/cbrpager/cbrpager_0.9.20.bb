require cbrpager.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "e1aee9221ec69ca8cc3a55093095ecf3"
SRC_URI[sha256sum] = "8838c53c49d2982c4d716ff5f241cf7168d5c4c5888cd73db21e73402dd5db39"
