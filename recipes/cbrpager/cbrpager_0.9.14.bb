require cbrpager.inc

PR = "${INC_PR}.1"

SRC_URI[md5sum] = "0ce88fc52025b44812d090d10244b2a4"
SRC_URI[sha256sum] = "9c86a5668a2834f02ec44967737d6341c575e2a1deec76944f47be0292a3cfd7"
