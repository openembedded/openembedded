require glibc_${PV}.bb
require glibc-initial.inc

SRC_URI[md5sum] = "bfdce99f82d6dbcb64b7f11c05d6bc96"
SRC_URI[sha256sum] = "e73ff5eddea95d09238b41d3c9c4d9ccddcf99fcc93d04956599c91c704f4a8e"
SRC_URI[md5sum] = "d4eeda37472666a15cc1f407e9c987a9"
SRC_URI[sha256sum] = "6c3bc4a247d1e5308fb14f81956802f09095d3683219859fcad5795aa3aea638"
SRC_URI[md5sum] = "bb8da838930b8c6d06bafdbaad5dab1a"
SRC_URI[sha256sum] = "43cb2a382f30d189f0cacb71cbfa0b153a45a49e5fd73330893d24731fca4eb6"
SRC_URI[md5sum] = "1acb1e6c444ad45bb1390e7800dc4d7c"
SRC_URI[sha256sum] = "b301918536819d00b824e134fbdeba3cf4048da060e70e75c8ea56fd92689ad9"
SRC_URI[md5sum] = "709cb2283068145e557912b0907341a3"
SRC_URI[sha256sum] = "9dba644da5db0ec5104698706854dcd4ae8d6a10e9419eb049e3d6fcad9d81fe"
SRC_URI[md5sum] = "79ddbf5e5721442c5753344e4ecdda1c"
SRC_URI[sha256sum] = "c1ab6923fa4388407cd1dcb2ed441f25c2b9fa18cacf6aad549c31fed3c08f8c"
SRC_URI[md5sum] = "c4d41a712bf40dfb852e7bc18e1b6c52"
SRC_URI[sha256sum] = "81611592bf30b4c1fa0c58d170d74c970dbc145127e16cb90d648663e2970cbf"
SRC_URI[md5sum] = "336ce18c81fe8d7c17d2f7a0dbd62766"
SRC_URI[sha256sum] = "9487f1d4c05b9c94d94f8bcb34541ef04b77cfc0526dbb0b344c67f2ab388c5b"
SRC_URI[md5sum] = "c89aac92d100761a767b9d5619fe582f"
SRC_URI[sha256sum] = "3033d84fd9a62d20a8cb0d42645d7cd5a28d2d108afcb4cc2d89db3dc1e328df"
SRC_URI[md5sum] = "dc31c9e01df62cba9457af7e9b9c968e"
SRC_URI[sha256sum] = "a69760ed0ea54b66c31d58cb32c7b23185a6b1d16f38dab8380ec4f2183b122d"
SRC_URI[md5sum] = "88fa901c9a85633ab62365b0ee9df3b1"
SRC_URI[sha256sum] = "6651eb15c9f6dabf21af4067b723cb29a87827f66570bfab74fdc00d80cab129"
SRC_URI[md5sum] = "b94605c3b7ba90bc01648ca6e5cc1aaf"
SRC_URI[sha256sum] = "16ff3ea972065925338da1a1f37322dc4d8774f6d34d2dde2ce85121c08c99e0"
SRC_URI[md5sum] = "b89be3e1653ec6df317e30a10a0933b5"
SRC_URI[sha256sum] = "0b5dd58a5240440ab6dcc0e2278bb99ebb20d0b558578652da59007bf27ae2fe"
