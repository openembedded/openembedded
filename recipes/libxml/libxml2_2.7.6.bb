require libxml2.inc

PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "7740a8ec23878a2f50120e1faa2730f2"
SRC_URI[archive.sha256sum] = "238c4f0203c012e5776522640c0fb3ac532c4064981c1ce3e74c00b75501d761"
