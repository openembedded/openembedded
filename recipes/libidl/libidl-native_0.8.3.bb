SECTION = "libs"
require libidl_${PV}.bb
inherit native

DEPENDS = "glib-2.0-native"

SRC_URI[md5sum] = "39640ea026d81e721b0c78a8aaeb7d59"
SRC_URI[sha256sum] = "808cd8e7b499a3519f8492a5bda75c55e770f976c98b2c2c21edcca4b9c30168"
