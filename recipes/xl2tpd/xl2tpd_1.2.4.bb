PR = "${INC_PR}.0"
require xl2tpd.inc

SRC_URI[md5sum] = "d94fc8a13596f12a561240dfcea9f977"
SRC_URI[sha256sum] = "3e6b4314a5100a576dd075684873b1e8b84b58f7f5ceb10731fabd3ebefaa8c4"

