require xl2tpd.inc
PR = "${INC_PR}.0"

SRC_URI += " file://cflags.patch"

SRC_URI[md5sum] = "8122d6daf53856b5b3b5425ea947c245"
SRC_URI[sha256sum] = "c807c243ee91e344f4f46718fd45565c1242463b4945c1428a4d1c513a418c15"

