AUTHOR = "lucky"
DESCRIPTION = "Illume keyboard with russian layout for the Terminal"
PV = "0.0-gitr${SRCREV}"
PR = "r0"

BASEDIR = "russian-terminal"
INSTFILES = "Terminal_Russian.kbd Terminal-russian-ru.png"

require illume-keyboard.inc
