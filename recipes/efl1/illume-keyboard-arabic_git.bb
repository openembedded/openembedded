AUTHOR = "Mohammad Fahmi / Tom Hacohen"
DESCRIPTION = "Illume keyboard with arabic layout"
PV = "0.0-gitr${SRCREV}"
PR = "r0"

BASEDIR = "arabic"
INSTFILES = "Arabic.kbd Arabic.png"

require illume-keyboard.inc


