AUTHOR = "Tom Hacohen"
DESCRIPTION = "Illume keyboard with hebrew layout"
PV = "0.0+gitr${SRCREV}"
PE = "1"
PR = "r0"

BASEDIR = "hebrew"
INSTFILES = "Hebrew.kbd Alpha-hebrew-il.png"

require illume-keyboard.inc


