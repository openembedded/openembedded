AUTHOR = "Florian Hackenberger"
DESCRIPTION = "Illume keyboard with german layout"
PV = "0.0-gitr${SRCREV}"
PR = "r0"

BASEDIR = "german"
INSTFILES = "German.kbd German.png"

require illume-keyboard.inc


