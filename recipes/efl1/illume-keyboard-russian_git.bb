AUTHOR = "lucky"
DESCRIPTION = "Illume keyboard with russian layout"
PV = "0.0+gitr${SRCPV}"
PE = "1"
PR = "r0"

BASEDIR = "russian"
INSTFILES = "X8_Russian.kbd X8-russian-ru.png"

require illume-keyboard.inc


