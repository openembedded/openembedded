AUTHOR = "Pander"
DESCRIPTION = "Illume keyboard with an alternative default layout"
PV = "0.0+gitr${SRCREV}"
PE = "1"
PR = "r0"

BASEDIR = "default-alt"
INSTFILES = "Default-alt.kbd"

require illume-keyboard.inc


