DESCRIPTION = "Illume keyboard with french layout"
PV = "0.0+gitr${SRCPV}"
PE = "1"
PR = "r0"

BASEDIR = "french"
INSTFILES = "Azerty.kbd Azerty.png"

require illume-keyboard.inc


