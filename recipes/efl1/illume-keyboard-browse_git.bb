AUTHOR = "Pander"
DESCRIPTION = "Illume keyboard with a layout optimized for browsing"
PV = "0.0+gitr${SRCREV}"
PE = "1"
PR = "r0"

BASEDIR = "browse"
INSTFILES = "\
Browse.kbd \
end-browse.png \
pagedown-browse.png \
browse.png \
home-browse.png \
pageup-browse.png \
space-browse.png \
"

require illume-keyboard.inc


