DESCRIPTION = "Evolve allows you to write ETK designs using a C-like language"
LICENSE = "MIT"
DEPENDS = "etk evolve-native"
PV = "0.1.0.001+svnr${SRCPV}"
PR = "r2"
SRCREV = "${EFL_SRCREV}"

inherit efl
