AUTHOR = "Pander"
DESCRIPTION = "Illume keyboard with an alternative numeric layout"
PV = "0.0+gitr${SRCREV}"
PE = "1"
PR = "r0"

BASEDIR = "numeric-alt"
INSTFILES = "\
end-alt.png \
home-alt.png \
Numbers-alt.kbd \
numeric-alt.png \
pagedown-alt.png \
pageup-alt.png \
"

require illume-keyboard.inc


