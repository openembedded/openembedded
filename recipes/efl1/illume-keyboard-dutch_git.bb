AUTHOR = "Pander"
DESCRIPTION = "Illume keyboard with dutch layout"
PV = "0.0+gitr${SRCREV}"
PE = "1"
PR = "r0"

BASEDIR = "dutch"
INSTFILES = "\
capslock-negative.png \
end.png \
pagedown.png \
qwerty-dutch-nl.png \
Terminal-dutch-nl.kbd \
capslock.png \
home.png \
pageup.png \
space.png \
"

require illume-keyboard.inc


