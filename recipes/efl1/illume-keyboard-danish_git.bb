AUTHOR = "Esben Damgaard"
DESCRIPTION = "Illume keyboard with danish layout"
PV = "0.0+gitr${SRCPV}"
PE = "1"
PR = "r0"

BASEDIR = "danish"
INSTFILES = "Danish.kbd danish.png"

require illume-keyboard.inc


