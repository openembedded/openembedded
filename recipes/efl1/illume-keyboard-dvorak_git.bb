AUTHOR = "Gabor Adam TOTH"
DESCRIPTION = "Illume keyboard with dvorak layout"
PV = "0.0-gitr${SRCREV}"
PR = "r0"

BASEDIR = "dvorak"
INSTFILES = "Dvorak.kbd dvorak.png"

require illume-keyboard.inc


