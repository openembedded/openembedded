PR = "r1"

require radvd.inc

MD5SUM = "8bce4a21757cf069f5a69e2f9bee9e5b"

SRC_URI[md5sum] = "8bce4a21757cf069f5a69e2f9bee9e5b"
SRC_URI[sha256sum] = "fbc44fac8356426c115914eb5dce6fc84afea923ad6aba1670a3402c06bda7ab"
