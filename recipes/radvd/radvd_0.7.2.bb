PR = "r2"

SRC_URI_append += "file://automake.patch;patch=1 "

require radvd.inc

MD5SUM = "26ea468b2323e44cf827ae5f84d18dc8"

SRC_URI[md5sum] = "26ea468b2323e44cf827ae5f84d18dc8"
SRC_URI[sha256sum] = "66ed3cbb85c77aaf8293e3e5df678dc9ade82253628d2ce8cec570655cf157e9"
