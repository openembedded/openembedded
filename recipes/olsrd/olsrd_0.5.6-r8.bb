require olsrd.inc

PR = "r2"

SRC_URI += "file://olsrd-0.5.6-unbreak-makefile.patch;patch=1"

