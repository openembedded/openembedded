require olsrd.inc

PR = "r1"

SRC_URI += "file://unbreak-makefile.patch;patch=1"


SRC_URI[md5sum] = "786fdf52adeb0d421905332312e5b75f"
SRC_URI[sha256sum] = "9c495773e9605a67b6cdbbc3fb70449b830ed55eb6e0082778a0ccf941b4b426"
