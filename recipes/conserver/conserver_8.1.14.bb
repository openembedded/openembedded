PR = "r3"

require conserver.inc

SRC_URI[md5sum] = "f7825728e5af8992ed4a99fb560a3df8"
SRC_URI[sha256sum] = "48a9e2f8a02054bc6740ae354433bfa1636a6e726f2d62af22752d7a6103410b"
