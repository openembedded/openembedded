PR = "r4"

require conserver.inc

SRC_URI[md5sum] = "7f53d7a0bb05ad16116fb99f17bf06f0"
SRC_URI[sha256sum] = "cb007ea21edb0e11f9e3a8a72c1623ce2718c49b7ddcabe6b815504b13d47c56"
