require ${PN}.inc

PV = "${OPIE_GIT_PV}"
PR = "r7"
SRC_URI = "${OPIE_GIT};protocol=git;subpath=pics"
