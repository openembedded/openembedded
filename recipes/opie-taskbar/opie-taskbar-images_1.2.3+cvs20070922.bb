require ${PN}.inc

PR = "r2"
SRCDATE = "20070922"
SRC_URI = "${HANDHELDS_CVS};module=opie/pics"
