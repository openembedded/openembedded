require gpe-bluetooth.inc

SRC_URI[md5sum] = "274dc2392120177ab88c5ecaca92ffde"
SRC_URI[sha256sum] = "a20f1fc9b1f5d1a2d6e4cd85cf8e81301f63dc94f93b913318a737752be3f545"
