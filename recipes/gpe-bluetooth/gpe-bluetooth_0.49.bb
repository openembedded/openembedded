require gpe-bluetooth.inc

DEPENDS = "gtk+ libdisplaymigration libgpewidget openobex libgpevtype bluez-libs sqlite dbus-glib libglade blueprobe bluez-utils-dbus libcontactsdb"

SRC_URI[md5sum] = "fd8e7708a0ca7ef70b60741ad210c4c2"
SRC_URI[sha256sum] = "0f6a83697edbab14ee47d9f2a84de12eb66a1f76169328b2410b2cb90604a487"
