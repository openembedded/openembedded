require gpe-bluetooth.inc

PR = "r0"


SRC_URI[md5sum] = "33faa8e3650bc82dec54da1f4d7654d7"
SRC_URI[sha256sum] = "f509c52ba12d378cba031e280d59489dbd7d5e08ff3dd22d14f40d669db0668c"
