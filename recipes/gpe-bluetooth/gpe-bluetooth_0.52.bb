require gpe-bluetooth.inc

SRC_URI[md5sum] = "ed12955524a0f65f83b33b23f260cf94"
SRC_URI[sha256sum] = "7d85be0973837d5499f0410179f84ac1351dba88eea22eabb13f86b65c7250ee"
