require gpe-bluetooth.inc

PR = "r1"

do_configure () {
	autotools_do_configure
}

SRC_URI[md5sum] = "202ddaf102791f504e543593b88eff1d"
SRC_URI[sha256sum] = "d6c2534e5e54bb24dbdb0e28085f92a076532a890655db7d37a56aa64d73e521"
