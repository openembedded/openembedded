require xautomation.inc

PR = "r0"

SRC_URI[md5sum] = "5051d633c15a0aac8c6eada281584d1d"
SRC_URI[sha256sum] = "019578691e8ab02532e35033331e275b658b360033e9e34dfdecf4774d161e3c"
