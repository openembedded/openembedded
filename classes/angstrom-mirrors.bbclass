MIRRORS_append () {
ftp://.*/.*/	http://www.angstrom-distribution.org/unstable/sources/
http://.*/.*/	http://www.angstrom-distribution.org/unstable/sources/
}
