PREMIRRORS_append () {
cvs://.*/.* http://sourceforge.net/projects/kaeilos/files/repo/
svn://.*/.* http://sourceforge.net/projects/kaeilos/files/repo/
git://.*/.* http://sourceforge.net/projects/kaeilos/files/repo/
hg://.*/.* http://sourceforge.net/projects/kaeilos/files/repo/
bzr://.*/.* http://sourceforge.net/projects/kaeilos/files/repo/
}

MIRRORS_append () {
ftp://.*/.*	http://sourceforge.net/projects/kaeilos/files/repo/
https?$://.*/.*	http://sourceforge.net/projects/kaeilos/files/repo/
}
