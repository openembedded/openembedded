PREMIRRORS() {
https?://.*/.* ${SOURCE_MIRROR_URL}
ftp://.*/.*  ${SOURCE_MIRROR_URL}
}
