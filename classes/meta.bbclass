
PACKAGES = ""

BUILD_ALL_DEPS = "1"
do_build[recrdeptask] = "do_build"