MIRRORS_append () {
ftp://.*/.*	http://sources.nslu2-linux.org/sources/
https?://.*/.*	http://sources.nslu2-linux.org/sources/
}
