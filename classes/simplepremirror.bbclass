PREMIRRORS_prepend () {
ftp://.*/.*/  ${SIMPLE_PREMIRROR}
http://.*/.*/  ${SIMPLE_PREMIRROR}
}
