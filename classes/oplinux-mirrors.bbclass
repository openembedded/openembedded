MIRRORS_append () {
ftp://.*/.*/	http://www.ifaistos.awmn/oplinux/stable/sources/
http://.*/.*/	http://www.ifaistos.awmn/oplinux/stable/sources/
ftp://.*/.*/	http://www.ifaistos.awmn/oplinux/unstable/sources/
http://.*/.*/	http://www.ifaistos.awmn/oplinux/unstable/sources/

ftp://.*/.*/	http://www.ifaistos.awmn/oplinux-uclibc/stable/sources/
http://.*/.*/	http://www.ifaistos.awmn/oplinux-uclibc/stable/sources/
ftp://.*/.*/	http:///www.ifaistos.awmn/oplinux-uclibc/unstable/sources/
http://.*/.*/	http://www.ifaistos.awmn/oplinux-uclibc/unstable/sources/

ftp://.*/.*/	http://digital-opsis.com/oplinux/stable/sources/
http://.*/.*/	http://digital-opsis.com/oplinux/stable/sources/
ftp://.*/.*/	http://digital-opsis.com/oplinux/unstable/sources/
http://.*/.*/	http://digital-opsis.com/oplinux/unstable/sources/

ftp://.*/.*/	http://digital-opsis.com/oplinux-uclibc/stable/sources/
http://.*/.*/	http://digital-opsis.com/oplinux-uclibc/stable/sources/
ftp://.*/.*/	http://digital-opsis.com/oplinux-uclibc/unstable/sources/
http://.*/.*/	http://digital-opsis.com/oplinux-uclibc/unstable/sources/
}
