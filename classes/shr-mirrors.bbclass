PREMIRRORS_append () {
cvs://.*/.* http://build.shr-project.org/sources/
svn://.*/.* http://build.shr-project.org/sources/
git://.*/.* http://build.shr-project.org/sources/
hg://.*/.* http://build.shr-project.org/sources/
bzr://.*/.* http://build.shr-project.org/sources/
}

MIRRORS_append () {
ftp://.*/.*	http://build.shr-project.org/sources/
https?$://.*/.*	http://build.shr-project.org/sources/
}

