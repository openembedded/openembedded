MIRRORS_append () {
ftp://.*/.*	http://meshcube.org/nylon/stable/sources/
https?://.*/.*	http://meshcube.org/nylon/stable/sources/
ftp://.*/.*	http://meshcube.org/nylon/unstable/sources/
https?://.*/.*	http://meshcube.org/nylon/unstable/sources/
}